options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: DRF To File
  states: {}

blocks:
- name: drfsink_directory
  id: variable
  parameters:
    value: '"/Users/vivelpanel/Desktop/SRT UROP 2022/Testing DRF Scripts/rtl-output/2xDrfout"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: source_directory
  id: variable
  parameters:
    value: '''/Volumes/NO NAME/pulsar/2022-05-26/rf_data'''
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/vivelpanel/Desktop/SRT UROP 2022/Testing DRF Scripts/rtl-output/source_block_output
    type: int
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: Empty
    file: /Users/vivelpanel/Desktop/SRT UROP 2022/Testing DRF Scripts/rtl-output/source_block_output
    type: short
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: This pathway makes empty file of ints.
    samples_per_second: samp_rate
    type: int
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    comment: |-
      This pathway ALSO
      makes empty file, but
      of shorts.
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: short
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    comment: |-
      This is empyt too (only has
      metadata, no samples.)
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: s16
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: '0'
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: drfsink_directory
    uuid: adsf
    vlen: '1'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: misa-l2
    comment: Supposed to read a bunch of samples.
    end0: int(1653595299999999)
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'True'
    start0: int(1653595200000000)
    throttle: 'False'
    top_level_dir: source_directory
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle_0_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_throttle_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
