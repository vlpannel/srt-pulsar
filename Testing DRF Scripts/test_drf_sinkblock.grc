options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: RTL-SDR to DRF
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 25e6
    step: '1'
    stop: 1750e6
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/vivelpanel/Desktop/SRT UROP 2022/Testing DRF Scripts/rtl-output/file_sink_output
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1000'
    type: complex
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[center_freq]'
    channel0: ch0
    checksum: 'False'
    comment: |-
      To test if this block works: saves
      data from RTL-SDR into a Digital
      RF file.

      ... It does not. The resulting DRF
      channel directory has no samples,
      only metadata.

      ... though maybe I should try using
      THORosmo source block next.

      Make sure to delete directory if it
      already exists (otherwise raises an
      error w/ return code 1).
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: s16
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: '"now"'
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: /Users/vivelpanel/Desktop/SRT UROP 2022/Testing DRF Scripts/rtl-output/rtl-drf/
    uuid: '''rtl-sdr-sink-test'''
    vlen: '1'
  states: {}
- name: note_0
  id: note
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''''''
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      To ensure that GNU Radio
      is actually reading the signals
      from the RTL-SDR source.
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_stream_to_vector_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
