options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: prototype_folding
    output_language: python
    title: 'Prototype Flowgraph: Folding'
  states: {}

blocks:
- name: bins
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: channel
  id: variable
  parameters:
    comment: |-
      Channel
      name
    value: '''ch0'''
  states: {}
- name: nsamps
  id: variable
  parameters:
    value: int(secs*sr)
  states: {}
- name: num_subchannels
  id: variable
  parameters:
    comment: |-
      Number of subchannels
      in channel
    value: '1'
  states: {}
- name: period
  id: variable
  parameters:
    comment: |-
      Pulsar and folding
      period (may later
      change to be
      different?)
    value: 33.5028583*1e-3
  states: {}
- name: pfb_data
  id: variable
  parameters:
    comment: |-
      Top level directory for stored
      DRF data
    value: '"C:\\Users\\vlpannel\\Desktop\\pfb_sim"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: secs
  id: variable
  parameters:
    value: '5'
  states: {}
- name: sr
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: np.ones(bins) * 10
    type: float
    vlen: bins
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: np.ones(bins) * 20
    type: float
    vlen: bins
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: np.ones(bins) * 30
    type: float
    vlen: bins
  states: {}
- name: blocks_add_const_vxx_0_2
  id: blocks_add_const_vxx
  parameters:
    const: np.ones(bins) * 40
    type: float
    vlen: bins
  states: {}
- name: blocks_add_const_vxx_0_3
  id: blocks_add_const_vxx
  parameters:
    const: np.ones(bins) * 50
    type: float
    vlen: bins
  states: {}
- name: blocks_add_const_vxx_0_4
  id: blocks_add_const_vxx
  parameters:
    const: np.ones(bins) * 60
    type: float
    vlen: bins
  states: {}
- name: blocks_msg_meta_to_pair_0
  id: blocks_msg_meta_to_pair
  parameters:
    keyin: '''samples_per_second'''
    keyout: '''samp_rate'''
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    comment: Sample rate according to DRF file
    target: sr
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '7'
    type: float
    vlen: bins
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Controlling flow (no hardware here)
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          samps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, samps=int(5e6), samp_rate=1e6, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, samps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              samps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = samps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(self.nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    pfold: period
    samp_rate: sr
    samps: nsamps
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(5e6), samp_rate=1e6, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: sr
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(5e6), samp_rate=1e6, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: sr
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(5e6), samp_rate=1e6, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: sr
  states: {}
- name: epy_block_0_2_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(5e6), samp_rate=1e6, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: sr
  states: {}
- name: epy_block_0_2_1
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(5e6), samp_rate=1e6, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: sr
  states: {}
- name: epy_block_0_2_2
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(5e6), samp_rate=1e6, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: sr
  states: {}
- name: gr_digital_rf_digital_rf_source_0_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: ch0
    channel1: ch1
    channel2: ch2
    channel3: ch3
    channel4: ch26
    channel5: ch27
    channel6: ch28
    end0: ''
    end1: ''
    end2: ''
    end3: ''
    end4: ''
    end5: ''
    end6: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '7'
    repeat: 'False'
    start0: ''
    start1: ''
    start2: ''
    start3: ''
    start4: ''
    start5: ''
    start6: ''
    throttle: 'False'
    top_level_dir: pfb_data
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Remember to 
      change the 
      default values
      when nsamps
      changes!
    note: folding
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Remember to pay attention
      to connections here if
      subchannels change!
    note: Subchannels change
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      Remember to alter data types
      if file outputs different type!
    note: Assumes Complex (complex32)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '7'
    vlen: bins
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_add_const_vxx_0_0, '0', qtgui_vector_sink_f_0, '2']
- [blocks_add_const_vxx_0_1, '0', qtgui_vector_sink_f_0, '3']
- [blocks_add_const_vxx_0_2, '0', qtgui_vector_sink_f_0, '4']
- [blocks_add_const_vxx_0_3, '0', qtgui_vector_sink_f_0, '5']
- [blocks_add_const_vxx_0_4, '0', qtgui_vector_sink_f_0, '6']
- [blocks_msg_meta_to_pair_0, outpair, blocks_msgpair_to_var_0, inpair]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0_0, '0', epy_block_0_2_0, '0']
- [blocks_stream_to_vector_0_1_0_0_0_0, '0', epy_block_0_2_1, '0']
- [blocks_stream_to_vector_0_1_0_0_0_0_0, '0', epy_block_0_2_2, '0']
- [blocks_stream_to_vector_1, '0', epy_block_0_0, '0']
- [blocks_stream_to_vector_1_0, '0', epy_block_0_1, '0']
- [blocks_stream_to_vector_2, '0', epy_block_0_2, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_0, '1', blocks_null_sink_1, '0']
- [epy_block_0_0, '0', blocks_add_const_vxx_0, '0']
- [epy_block_0_0, '1', blocks_null_sink_1, '1']
- [epy_block_0_1, '0', blocks_add_const_vxx_0_0, '0']
- [epy_block_0_1, '1', blocks_null_sink_1, '2']
- [epy_block_0_2, '0', blocks_add_const_vxx_0_1, '0']
- [epy_block_0_2, '1', blocks_null_sink_1, '3']
- [epy_block_0_2_0, '0', blocks_add_const_vxx_0_2, '0']
- [epy_block_0_2_0, '1', blocks_null_sink_1, '4']
- [epy_block_0_2_1, '0', blocks_add_const_vxx_0_3, '0']
- [epy_block_0_2_1, '1', blocks_null_sink_1, '5']
- [epy_block_0_2_2, '0', blocks_add_const_vxx_0_4, '0']
- [epy_block_0_2_2, '1', blocks_null_sink_1, '6']
- [gr_digital_rf_digital_rf_source_0_0, '0', blocks_stream_to_vector_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '1', blocks_stream_to_vector_1, '0']
- [gr_digital_rf_digital_rf_source_0_0, '2', blocks_stream_to_vector_1_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '3', blocks_stream_to_vector_2, '0']
- [gr_digital_rf_digital_rf_source_0_0, '4', blocks_stream_to_vector_0_0_0_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '5', blocks_stream_to_vector_0_1_0_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '6', blocks_stream_to_vector_0_1_0_0_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, properties, blocks_msg_meta_to_pair_0, inmeta]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
