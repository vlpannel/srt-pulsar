options:
  parameters:
    author: Viveca Pannell
    generate_options: hb
    id: fold_block_2
    output_language: python
    title: Fold 2
  states: {}

blocks:
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(integration_time/period)
    type: float
    vlen: int(samp_rate * period)
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: period/integration_time
    type: float
    vlen: int(samp_rate * period)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(samp_rate * period)
    type: float
  states: {}
- name: integration_time
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: int(samp_rate * period)
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: period
  id: parameter
  parameters:
    type: eng_float
    value: '.0335'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 1000000/32
  states: {}

connections:
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', pad_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_integrate_xx_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
