options:
  parameters:
    author: vlpannel
    generate_options: qt_gui
    id: sim_pfb
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '29'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '200'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import digital_rf as drf

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, datadir='C:\\Users\\vlpannel\\Desktop\\raw', chan='ch0'):
              gr.sync_block.__init__(
                  self,
                  name='DRF Read Entire Channel',   # will show up in GRC
                  in_sig=[],
                  out_sig=[(np.complex64, 200)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.datadir = datadir
              self.chan = chan

              self.drf_obj = drf.DigitalRFReader(self.datadir)
              self.s, self.e = self.drf_obj.get_bounds(self.chan)

              self.data = None
              
          def work(self, input_items, output_items):

              self.data = self.drf_obj.read_vector(self.s, 200, self.chan)
              self.s += 200
              
              output_items[0] = np.copy(self.data)
              return len(output_items[0])
    chan: '"ch0"'
    datadir: '"C:\\Users\\vlpannel\\Desktop\\raw"'
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    channel1: ch1
    channel10: ch10
    channel11: ch11
    channel12: ch12
    channel13: ch13
    channel14: ch14
    channel15: ch15
    channel16: ch16
    channel17: ch17
    channel18: ch18
    channel19: ch19
    channel2: ch2
    channel20: ch20
    channel21: ch21
    channel22: ch22
    channel23: ch23
    channel24: ch24
    channel25: ch25
    channel26: ch26
    channel27: ch27
    channel28: ch28
    channel3: ch3
    channel4: ch4
    channel5: ch5
    channel6: ch6
    channel7: ch7
    channel8: ch8
    channel9: ch9
    checksum: 'False'
    comment: |-
      Should eventually find a way to
      pass along metadata at this stage,
      but will not for now.

      DRF Sink DOES work.
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '29'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: C:\\Users\\vlpannel\\Desktop\\pfbdata
    uuid: ''
    vlen: '1'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: ch0
    comment: |-
      Danger: this doesn't work

      Gives error:
      	thread_body_wrapper
      	:error: ERROR thread[
      	thread-per-block[0]:
      	<block
      	digital_rf_channel_source(6)>]:
      	TypeError: unsupported
      	operand type(s) for /: 'int'
      	and 'numpy.longdouble'
    end0: '1659472223999999'
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'True'
    start0: '1659472206000000'
    throttle: 'False'
    top_level_dir: C:\\Users\\vlpannel\\Desktop\\raw
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from mitarspysigproc import filtertools
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import digital_rf
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    nchans: '31'
    osr: '1.0'
    taps: filtertools.kaiser_coeffs(31)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: For testing
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: For testing
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_throttle_0, '0']
- [pfb_channelizer_ccf_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', gr_digital_rf_digital_rf_sink_0, '1']
- [pfb_channelizer_ccf_0, '10', gr_digital_rf_digital_rf_sink_0, '10']
- [pfb_channelizer_ccf_0, '10', qtgui_sink_x_0_0, '0']
- [pfb_channelizer_ccf_0, '11', gr_digital_rf_digital_rf_sink_0, '11']
- [pfb_channelizer_ccf_0, '12', gr_digital_rf_digital_rf_sink_0, '12']
- [pfb_channelizer_ccf_0, '13', gr_digital_rf_digital_rf_sink_0, '13']
- [pfb_channelizer_ccf_0, '14', gr_digital_rf_digital_rf_sink_0, '14']
- [pfb_channelizer_ccf_0, '15', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '16', blocks_null_sink_0, '1']
- [pfb_channelizer_ccf_0, '17', gr_digital_rf_digital_rf_sink_0, '15']
- [pfb_channelizer_ccf_0, '18', gr_digital_rf_digital_rf_sink_0, '16']
- [pfb_channelizer_ccf_0, '19', gr_digital_rf_digital_rf_sink_0, '17']
- [pfb_channelizer_ccf_0, '2', gr_digital_rf_digital_rf_sink_0, '2']
- [pfb_channelizer_ccf_0, '20', gr_digital_rf_digital_rf_sink_0, '18']
- [pfb_channelizer_ccf_0, '21', gr_digital_rf_digital_rf_sink_0, '19']
- [pfb_channelizer_ccf_0, '22', gr_digital_rf_digital_rf_sink_0, '20']
- [pfb_channelizer_ccf_0, '23', gr_digital_rf_digital_rf_sink_0, '21']
- [pfb_channelizer_ccf_0, '24', gr_digital_rf_digital_rf_sink_0, '22']
- [pfb_channelizer_ccf_0, '25', gr_digital_rf_digital_rf_sink_0, '23']
- [pfb_channelizer_ccf_0, '26', gr_digital_rf_digital_rf_sink_0, '24']
- [pfb_channelizer_ccf_0, '27', gr_digital_rf_digital_rf_sink_0, '25']
- [pfb_channelizer_ccf_0, '28', gr_digital_rf_digital_rf_sink_0, '26']
- [pfb_channelizer_ccf_0, '29', gr_digital_rf_digital_rf_sink_0, '27']
- [pfb_channelizer_ccf_0, '3', gr_digital_rf_digital_rf_sink_0, '3']
- [pfb_channelizer_ccf_0, '30', gr_digital_rf_digital_rf_sink_0, '28']
- [pfb_channelizer_ccf_0, '4', gr_digital_rf_digital_rf_sink_0, '4']
- [pfb_channelizer_ccf_0, '5', gr_digital_rf_digital_rf_sink_0, '5']
- [pfb_channelizer_ccf_0, '6', gr_digital_rf_digital_rf_sink_0, '6']
- [pfb_channelizer_ccf_0, '7', gr_digital_rf_digital_rf_sink_0, '7']
- [pfb_channelizer_ccf_0, '8', gr_digital_rf_digital_rf_sink_0, '8']
- [pfb_channelizer_ccf_0, '9', gr_digital_rf_digital_rf_sink_0, '9']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
