options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: store_channels
    output_language: python
    title: Channelize DRF Data
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: subchannels
  id: variable
  parameters:
    comment: |-
      The number of
      subchannels a
      channel being
      read has.
    value: '2'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '10'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: subchannels
    type: short
  states: {}
- name: bounds
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      import digital_rf

      source_filepath = '/Volumes/NO NAME/pulsar/2022-05-26/rf_data'
      sink_filepath = '/Users/vivelpanel/Desktop/SRT UROP 2022/Spectrogram/drf_out'
      d = digital_rf.DigitalRFReader(source_filepath)
      channel = 'misa-l2'

      def check_channel():
          """
          Checks to make sure channel is within source of RF data. Raises AssertionError if not.
          """
          try:
              assert channel in d.get_channels()
          except AssertionError:
              print('That channel isn\'t in this data!')

      def sindex(offset):
          """
          Generates a start index of DRF reading by returning the index of the first sample in channel plus some offset.

          Parameters:
              offset : int
                  Integer offset for how many samples after first sample should start reading.
          """
          check_channel()
          return d.get_bounds(channel)[0]

      def eindex(factor):
          """
          Generates an end index of DRF reading by returning the index of a sample that is 1/factor the way through the entire series of samples.

          Parameters:
              factor : int or float
                  Denominator for proportion of samples to be read, eg., if factor is 10 then 1/10 of samples will be read.
          """
          check_channel()
          s, e = d.get_bounds(channel)
          return (e - s) / factor
  states: {}
- name: chan_name
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      """
      This code generates the names of the files that store each channel output.
      """

      class ChannelFile:
          basename = '/chan/created_channel_'
          index = 0

          def __init__(self, param=1):
              self.filename = basename + str(index)
              index += 1

          def get_name(self):
              return self.filename
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{''grc_generated'': True, ''input_type'': ''vector length10 cf64''}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: bounds.sindex(1000)
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: bounds.sink_filepath
    uuid: hopethisfirsttryworks
    vlen: '10'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: misa-l2
    end0: bounds.eindex(100)
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'True'
    start0: bounds.sindex(0)
    throttle: 'False'
    top_level_dir: bounds.source_filepath
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      DRF Source block is not filled
      out and chan_name script is
      not complete (doesn't include
      file path).
    note: Currently nonfunctional
  states: {state: disabled}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: '10'
    osr: '1.0'
    taps: '[]'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_streams_to_vector_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_throttle_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_vector_to_streams_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_streams_to_vector_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_streams_to_vector_0, '1']
- [pfb_channelizer_ccf_0, '2', blocks_streams_to_vector_0, '2']
- [pfb_channelizer_ccf_0, '3', blocks_streams_to_vector_0, '3']
- [pfb_channelizer_ccf_0, '4', blocks_streams_to_vector_0, '4']
- [pfb_channelizer_ccf_0, '5', blocks_streams_to_vector_0, '5']
- [pfb_channelizer_ccf_0, '6', blocks_streams_to_vector_0, '6']
- [pfb_channelizer_ccf_0, '7', blocks_streams_to_vector_0, '7']
- [pfb_channelizer_ccf_0, '8', blocks_streams_to_vector_0, '8']
- [pfb_channelizer_ccf_0, '9', blocks_streams_to_vector_0, '9']

metadata:
  file_format: 1
