options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: store_channels
    output_language: python
    title: Channelize DRF Data
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: subchannels
  id: variable
  parameters:
    comment: |-
      The number of
      subchannels a
      channel being
      read has.
    value: '2'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: chan_name.name(0)
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: chan_name.name(1)
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: chan_name.name(2)
    type: complex
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: chan_name.name(3)
    type: complex
  states: {}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: chan_name.name(4)
    type: complex
  states: {}
- name: blocks_file_sink_0_4
  id: blocks_file_sink
  parameters:
    file: chan_name.name(5)
    type: complex
  states: {}
- name: blocks_file_sink_0_5
  id: blocks_file_sink
  parameters:
    file: chan_name.name(6)
    type: complex
  states: {}
- name: blocks_file_sink_0_6
  id: blocks_file_sink
  parameters:
    file: chan_name.name(7)
    type: complex
  states: {}
- name: blocks_file_sink_0_7
  id: blocks_file_sink
  parameters:
    file: chan_name.name(9)
    type: complex
  states: {}
- name: blocks_file_sink_0_8
  id: blocks_file_sink
  parameters:
    file: chan_name.name(8)
    type: complex
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: subchannels
    type: short
  states: {}
- name: chan_name
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      """
      This code generates the names of the files that store each channel output.
      """

      def name(num):
          return '/Users/vivelpanel/Desktop/SRT UROP 2022/Spectrogram/channels/created_channel_' + str(num)

      # will finish below code later--for now it is much more complicated
      # than necessary, so I use the simpler scheme above
      """
      class ChannelFile:
          filepath = '/Users/vivelpanel/Desktop/SRT UROP 2022/Spectrogram/channels/'
          basename = 'created_channel_'
          index = 0

          def __init__(self, num=index):
              self.filename = filepath + basename + str(num)
              if num == index:
                  index += 1

          def get_name(self, num):
              if 
              return self.filename
      """
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: ch0
    end0: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'False'
    top_level_dir: ''
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: '10'
    osr: '1.0'
    taps: '[]'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_throttle_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_vector_to_streams_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_file_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_file_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '2', blocks_file_sink_0_1, '0']
- [pfb_channelizer_ccf_0, '3', blocks_file_sink_0_2, '0']
- [pfb_channelizer_ccf_0, '4', blocks_file_sink_0_3, '0']
- [pfb_channelizer_ccf_0, '5', blocks_file_sink_0_4, '0']
- [pfb_channelizer_ccf_0, '6', blocks_file_sink_0_5, '0']
- [pfb_channelizer_ccf_0, '7', blocks_file_sink_0_6, '0']
- [pfb_channelizer_ccf_0, '8', blocks_file_sink_0_8, '0']
- [pfb_channelizer_ccf_0, '9', blocks_file_sink_0_7, '0']

metadata:
  file_format: 1
