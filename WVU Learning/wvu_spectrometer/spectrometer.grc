options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: spectrometer
    output_language: python
    title: Simple Spectrometer
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1.419e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_length)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: vec_length
    x_axis_label: '"Frequency (Hz)"'
    x_start: 1414e6
    x_step: samp_rate/vec_length
    x_units: '"Hz"'
    y_axis_label: '"Signal"'
    ymax: '10000'
    ymin: '0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0,bias=1
    bb_gain0: '10'
    freq0: freq
    gain0: '17'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
