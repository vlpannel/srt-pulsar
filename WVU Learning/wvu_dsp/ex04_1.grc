options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: dsp_4
    output_language: python
    title: FIR
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_movingaverage_0
  id: fir_movingaverage
  parameters: {}
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (0,0)
    name: '"Unfiltered"'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Filtered"'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', fir_movingaverage_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', fir_movingaverage_0, '0']
- [fir_movingaverage_0, '0', qtgui_sink_x_0, '0']
- [fir_movingaverage_0, '1', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
