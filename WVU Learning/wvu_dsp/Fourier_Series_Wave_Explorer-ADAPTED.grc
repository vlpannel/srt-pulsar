options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: Amplitude_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,3,1,1
    label: Constant
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: Amplitude_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Amplitude 1
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: Amplitude_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Amplitude 2
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: Amplitude_3
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Amplitude 3
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: Amplitude_4
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,3,1,1
    label: Amplitude 4
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: Amplitude_5
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2,1,1
    label: Amplitude 5
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: Mystery
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Mystery
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: MysteryWave
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Mystery Wave
    label0: Square
    label1: Triangle
    label2: Sawtooth
    num_opts: '3'
    option0: '103'
    option1: '104'
    option2: '105'
    type: int
    value: '103'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '1000'
    offset: '-1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: MysteryWave
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitude_3
    freq: 1000*3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitude_4
    freq: 1000*4
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitude_5
    freq: 1000*5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitude_0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: Amplitude_2
    freq: 1000*2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: Amplitude_1
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '6'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Mystery
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,2
    label1: ''
    label2: ''
    name: Sum of Waves and Mystery Wave
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: ''
    name: Wave 1
    size: '256'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Amplitude 1
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: ''
    name: Wave 2
    size: '256'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Amplitude 2
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    label1: ''
    name: Wave 3
    size: '256'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Amplitude 3
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,1
    label1: ''
    name: Wave 4
    size: '256'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Amplitude 4
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0,1,1
    label1: ''
    name: Wave 5
    size: '256'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Amplitude 5
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,1,1,1
    label1: ''
    name: Constant
    size: '256'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Amplitude 0
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_0, '3']
- [analog_sig_source_x_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_add_xx_0, '4']
- [analog_sig_source_x_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [analog_sig_source_x_0_0_0_0_0, '0', blocks_add_xx_0, '5']
- [analog_sig_source_x_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_sig_source_x_0_2, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_2, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
