options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: tuner_top_block
    output_language: python
    title: Tuner
  states: {}

blocks:
- name: a
  id: variable
  parameters:
    value: '110.0'
  states: {}
- name: b
  id: variable
  parameters:
    value: '246.94'
  states: {}
- name: d
  id: variable
  parameters:
    value: '146.83'
  states: {}
- name: g
  id: variable
  parameters:
    value: '196.0'
  states: {}
- name: high_e
  id: variable
  parameters:
    value: '329.63'
  states: {}
- name: low_e
  id: variable
  parameters:
    value: '82.41'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: width
  id: variable
  parameters:
    value: '10'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: low_e + width
    low_cutoff_freq: low_e - width
    samp_rate: samp_rate
    type: fir_filter_fff
    width: width / 2
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: a + width
    low_cutoff_freq: a - width
    samp_rate: samp_rate
    type: fir_filter_fff
    width: width / 2
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: d + width
    low_cutoff_freq: d - width
    samp_rate: samp_rate
    type: fir_filter_fff
    width: width / 2
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: g + width
    low_cutoff_freq: g - width
    samp_rate: samp_rate
    type: fir_filter_fff
    width: width / 2
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: b + width
    low_cutoff_freq: b - width
    samp_rate: samp_rate
    type: fir_filter_fff
    width: width / 2
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_3_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: high_e + width
    low_cutoff_freq: high_e - width
    samp_rate: samp_rate
    type: fir_filter_fff
    width: width / 2
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: low_e
    fftsize: '4096'
    gui_hint: (0,0)
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: a
    fftsize: '4096'
    gui_hint: (0,1)
    type: float
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: d
    fftsize: '4096'
    gui_hint: (0,2)
    type: float
  states: {}
- name: qtgui_sink_x_0_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: g
    fftsize: '4096'
    gui_hint: (1,0)
    type: float
  states: {}
- name: qtgui_sink_x_0_3
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: b
    fftsize: '4096'
    gui_hint: (1,1)
    plotfreq: 'False'
    type: float
  states: {}
- name: qtgui_sink_x_0_3_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: high_e
    fftsize: '4096'
    gui_hint: (1,2)
    plotfreq: 'False'
    type: float
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0, '0']
- [audio_source_0, '0', band_pass_filter_0_0, '0']
- [audio_source_0, '0', band_pass_filter_0_1, '0']
- [audio_source_0, '0', band_pass_filter_0_2, '0']
- [audio_source_0, '0', band_pass_filter_0_3, '0']
- [audio_source_0, '0', band_pass_filter_0_3_1, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [band_pass_filter_0_0, '0', qtgui_sink_x_0_0, '0']
- [band_pass_filter_0_1, '0', qtgui_sink_x_0_1, '0']
- [band_pass_filter_0_2, '0', qtgui_sink_x_0_2, '0']
- [band_pass_filter_0_3, '0', qtgui_sink_x_0_3, '0']
- [band_pass_filter_0_3_1, '0', qtgui_sink_x_0_3_0, '0']

metadata:
  file_format: 1
