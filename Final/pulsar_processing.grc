options:
  parameters:
    author: vlpannel
    generate_options: qt_gui
    id: final
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Get power
    vlen: channels - 2
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    comment: |-
      Not sure exactly how to
      pass on DRF metadata
    target: metadata
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: |-
      Throw away
      frequencies
      at edge of
      bandwidth
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: channels - 2
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: channels - 2
    type: float
  states: {}
- name: channels
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              Always outputs the last calculated phase vs. power profile.

              After calculating, immediately begins collecting data for a new calculation.
              
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enough data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_6
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_7
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_8
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    comment: |-
      Fold power over time

      Maybe make this
      a block with variable
      number of ports later.
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_10
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_11
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_12
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_13
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_14
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_15
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_16
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_17
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_18
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_19
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_6
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_7
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_8
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_9
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enought data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: 1000000/32
  states: {}
- name: gr_digital_rf_digital_rf_sink_1
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    channel1: ch1
    channel10: ch10
    channel11: ch11
    channel12: ch12
    channel13: ch13
    channel14: ch14
    channel15: ch15
    channel16: ch16
    channel17: ch17
    channel18: ch18
    channel19: ch19
    channel2: ch2
    channel20: ch20
    channel21: ch21
    channel22: ch22
    channel23: ch23
    channel24: ch24
    channel25: ch25
    channel26: ch26
    channel27: ch27
    channel28: ch28
    channel29: ch29
    channel3: ch3
    channel4: ch4
    channel5: ch5
    channel6: ch6
    channel7: ch7
    channel8: ch8
    channel9: ch9
    checksum: 'False'
    comment: Write/save data
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: f32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '30'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: save_dir
    uuid: ''
    vlen: '1024'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: '''misa-l'''
    channel1: '''misa-l2'''
    comment: Read data
    end0: ''
    end1: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '2'
    repeat: 'False'
    start0: ''
    start1: ''
    throttle: 'False'
    top_level_dir: source_dir
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import mitarspysigproc.filtertools as filter
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This flowgraph's
      configuration is
      specific to MISA
      data
    note: specific
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    comment: PFB
    nchans: channels
    osr: '1.0'
    taps: filter.kaiser_coeffs(channels)
  states: {}
- name: save_dir
  id: parameter
  parameters:
    type: str
    value: /path/to/save/data
  states: {}
- name: source_dir
  id: parameter
  parameters:
    comment: |-
      Top-level directory
      where Digital RF
      data is stored
    label: /path/to/source/data
    type: str
    value: '0'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_vector_to_streams_0, '0', epy_block_1, '0']
- [blocks_vector_to_streams_0, '1', epy_block_1_18, '0']
- [blocks_vector_to_streams_0, '10', epy_block_1_12, '0']
- [blocks_vector_to_streams_0, '11', epy_block_1_11, '0']
- [blocks_vector_to_streams_0, '12', epy_block_1_10, '0']
- [blocks_vector_to_streams_0, '13', epy_block_1_9, '0']
- [blocks_vector_to_streams_0, '14', epy_block_1_8, '0']
- [blocks_vector_to_streams_0, '15', epy_block_1_6, '0']
- [blocks_vector_to_streams_0, '16', epy_block_1_5, '0']
- [blocks_vector_to_streams_0, '17', epy_block_1_4, '0']
- [blocks_vector_to_streams_0, '18', epy_block_1_3, '0']
- [blocks_vector_to_streams_0, '19', epy_block_1_2, '0']
- [blocks_vector_to_streams_0, '2', epy_block_1_19, '0']
- [blocks_vector_to_streams_0, '20', epy_block_1_0, '0']
- [blocks_vector_to_streams_0, '21', epy_block_1_0_5, '0']
- [blocks_vector_to_streams_0, '22', epy_block_1_0_6, '0']
- [blocks_vector_to_streams_0, '23', epy_block_1_0_4, '0']
- [blocks_vector_to_streams_0, '24', epy_block_1_0_3, '0']
- [blocks_vector_to_streams_0, '25', epy_block_1_0_2, '0']
- [blocks_vector_to_streams_0, '26', epy_block_1_0_1, '0']
- [blocks_vector_to_streams_0, '27', epy_block_1_0_0, '0']
- [blocks_vector_to_streams_0, '28', epy_block_1_0_7, '0']
- [blocks_vector_to_streams_0, '29', epy_block_1_0_8, '0']
- [blocks_vector_to_streams_0, '3', epy_block_1_17, '0']
- [blocks_vector_to_streams_0, '4', epy_block_1_16, '0']
- [blocks_vector_to_streams_0, '5', epy_block_1_15, '0']
- [blocks_vector_to_streams_0, '6', epy_block_1_14, '0']
- [blocks_vector_to_streams_0, '7', epy_block_1_13, '0']
- [blocks_vector_to_streams_0, '8', epy_block_1_1, '0']
- [blocks_vector_to_streams_0, '9', epy_block_1_7, '0']
- [epy_block_1, '0', gr_digital_rf_digital_rf_sink_1, '0']
- [epy_block_1_0, '0', gr_digital_rf_digital_rf_sink_1, '20']
- [epy_block_1_0_0, '0', gr_digital_rf_digital_rf_sink_1, '27']
- [epy_block_1_0_1, '0', gr_digital_rf_digital_rf_sink_1, '26']
- [epy_block_1_0_2, '0', gr_digital_rf_digital_rf_sink_1, '25']
- [epy_block_1_0_3, '0', gr_digital_rf_digital_rf_sink_1, '24']
- [epy_block_1_0_4, '0', gr_digital_rf_digital_rf_sink_1, '23']
- [epy_block_1_0_5, '0', gr_digital_rf_digital_rf_sink_1, '21']
- [epy_block_1_0_6, '0', gr_digital_rf_digital_rf_sink_1, '22']
- [epy_block_1_0_7, '0', gr_digital_rf_digital_rf_sink_1, '28']
- [epy_block_1_0_8, '0', gr_digital_rf_digital_rf_sink_1, '29']
- [epy_block_1_1, '0', gr_digital_rf_digital_rf_sink_1, '8']
- [epy_block_1_10, '0', gr_digital_rf_digital_rf_sink_1, '12']
- [epy_block_1_11, '0', gr_digital_rf_digital_rf_sink_1, '11']
- [epy_block_1_12, '0', gr_digital_rf_digital_rf_sink_1, '10']
- [epy_block_1_13, '0', gr_digital_rf_digital_rf_sink_1, '7']
- [epy_block_1_14, '0', gr_digital_rf_digital_rf_sink_1, '6']
- [epy_block_1_15, '0', gr_digital_rf_digital_rf_sink_1, '5']
- [epy_block_1_16, '0', gr_digital_rf_digital_rf_sink_1, '4']
- [epy_block_1_17, '0', gr_digital_rf_digital_rf_sink_1, '3']
- [epy_block_1_18, '0', gr_digital_rf_digital_rf_sink_1, '1']
- [epy_block_1_19, '0', gr_digital_rf_digital_rf_sink_1, '2']
- [epy_block_1_2, '0', gr_digital_rf_digital_rf_sink_1, '19']
- [epy_block_1_3, '0', gr_digital_rf_digital_rf_sink_1, '18']
- [epy_block_1_4, '0', gr_digital_rf_digital_rf_sink_1, '17']
- [epy_block_1_5, '0', gr_digital_rf_digital_rf_sink_1, '16']
- [epy_block_1_6, '0', gr_digital_rf_digital_rf_sink_1, '15']
- [epy_block_1_7, '0', gr_digital_rf_digital_rf_sink_1, '9']
- [epy_block_1_8, '0', gr_digital_rf_digital_rf_sink_1, '14']
- [epy_block_1_9, '0', gr_digital_rf_digital_rf_sink_1, '13']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_null_sink_1, '0']
- [gr_digital_rf_digital_rf_source_0, '1', blocks_throttle_0, '0']
- [gr_digital_rf_digital_rf_source_0, properties, blocks_msgpair_to_var_0, inpair]
- [pfb_channelizer_ccf_0, '0', blocks_streams_to_vector_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_streams_to_vector_0, '1']
- [pfb_channelizer_ccf_0, '10', blocks_streams_to_vector_0, '10']
- [pfb_channelizer_ccf_0, '11', blocks_streams_to_vector_0, '11']
- [pfb_channelizer_ccf_0, '12', blocks_streams_to_vector_0, '12']
- [pfb_channelizer_ccf_0, '13', blocks_streams_to_vector_0, '13']
- [pfb_channelizer_ccf_0, '14', blocks_streams_to_vector_0, '14']
- [pfb_channelizer_ccf_0, '15', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '16', blocks_null_sink_0, '1']
- [pfb_channelizer_ccf_0, '17', blocks_streams_to_vector_0, '15']
- [pfb_channelizer_ccf_0, '18', blocks_streams_to_vector_0, '16']
- [pfb_channelizer_ccf_0, '19', blocks_streams_to_vector_0, '17']
- [pfb_channelizer_ccf_0, '2', blocks_streams_to_vector_0, '2']
- [pfb_channelizer_ccf_0, '20', blocks_streams_to_vector_0, '18']
- [pfb_channelizer_ccf_0, '21', blocks_streams_to_vector_0, '19']
- [pfb_channelizer_ccf_0, '22', blocks_streams_to_vector_0, '20']
- [pfb_channelizer_ccf_0, '23', blocks_streams_to_vector_0, '21']
- [pfb_channelizer_ccf_0, '24', blocks_streams_to_vector_0, '22']
- [pfb_channelizer_ccf_0, '25', blocks_streams_to_vector_0, '23']
- [pfb_channelizer_ccf_0, '26', blocks_streams_to_vector_0, '24']
- [pfb_channelizer_ccf_0, '27', blocks_streams_to_vector_0, '25']
- [pfb_channelizer_ccf_0, '28', blocks_streams_to_vector_0, '26']
- [pfb_channelizer_ccf_0, '29', blocks_streams_to_vector_0, '27']
- [pfb_channelizer_ccf_0, '3', blocks_streams_to_vector_0, '3']
- [pfb_channelizer_ccf_0, '30', blocks_streams_to_vector_0, '28']
- [pfb_channelizer_ccf_0, '31', blocks_streams_to_vector_0, '29']
- [pfb_channelizer_ccf_0, '4', blocks_streams_to_vector_0, '4']
- [pfb_channelizer_ccf_0, '5', blocks_streams_to_vector_0, '5']
- [pfb_channelizer_ccf_0, '6', blocks_streams_to_vector_0, '6']
- [pfb_channelizer_ccf_0, '7', blocks_streams_to_vector_0, '7']
- [pfb_channelizer_ccf_0, '8', blocks_streams_to_vector_0, '8']
- [pfb_channelizer_ccf_0, '9', blocks_streams_to_vector_0, '9']

metadata:
  file_format: 1
