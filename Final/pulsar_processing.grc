options:
  parameters:
    author: vlpannel
    generate_options: qt_gui
    id: final
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Get power
    vlen: channels - 2
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    comment: |-
      Not sure exactly how to
      pass on DRF metadata
    target: metadata
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: |-
      Throw away
      frequencies
      at edge of
      bandwidth
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_10
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_11
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_12
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_13
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_14
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_15
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_16
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_17
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_18
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_19
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Give folding block
      chunks of data to
      fold over
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_20
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_21
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_22
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_23
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_24
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_25
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_26
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_27
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_28
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_29
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_30
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_4
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_5
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_6
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_7
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_8
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_9
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples
    type: float
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: channels - 2
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: channels - 2
    type: float
  states: {}
- name: channels
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_block(gr.sync_block):
          """
          Fold a timeseries of power over a period.

          Parameters
          ----------

          num_inputs : int
              Number of channels of data to fold.
          
          samp_rate : float
              Original sample rate of data.
              
          num_channels : int
              Number of channels that data is split into.
              
          nsamps : int
              Number of samples (length of vector) passed in.
              
          period : float
              Period to fold over.
              
          nbins : int
              Number of bins to use when folding.
              
          save_external : bool
              Flag stating whether or not to save overall profile. If true, overall profile (sum of all profiles generated) will be saved to savefile.
              
          savefile : list of str      # probably want to fix this to include filepath
              Files to save all profiles to (if save_external is True). Must be of length greater than or equal to num_inputs.

          
          Outputs the profile resultant of the latest vector passed in.
          """

          def __init__(self, num_inputs=30, samp_rate=1000000., num_channels=32, nsamps=2048, period=.0335, nbins=1024, save_external=True, savefile=['']*1000):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Folding',
                  in_sig=[(np.float32, nsamps)] * num_inputs,
                  out_sig=[(np.float32, nbins)] * num_inputs
              )
              self.samp_rate = samp_rate  # original sample rate
              self.num_channels = num_channels    # number of channels in PFB
              self.nsamps = nsamps    # length of vector passed in (number of samples)
              self.period = period
              self.nbins = nbins
              self.save_external = save_external  # flag for whether or not to save total profile in its own binary file
              self.savefile = savefile
              
              self.ts = np.zeros(nsamps)
              self.start_time = 0.
              self.times = np.arange(nsamps) * (1 / (self.samp_rate/self.num_channels))
              self.counting = True

              self.profile = np.zeros(nbins)
              self.phibin_centers = np.zeros(nbins + 1)
              self.counts = np.zeros(nbins)
              self.folded = None

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for i in range(num_inputs):
                  # re-set time series and times
                  self.ts = np.array(input_items[i])
                  self.times += self.start_time
                  self.start_time += (self.times[1] + self.times[-1])

                  # fold and get results of folding
                  self.folded = fold.fold_ts(self.ts, self.times, self.period, self.nbins, return_counts=self.counting)
                  self.profile += self.folded[0]
                  self.phibin_centers = self.folded[1]
                  if self.counting:
                      self.counts += self.folded[2]

                  # save overall profile by overwriting save file
                  if self.save_external:
                      np.save(self.profile[i])   # read this by calling np.load(filename)

                  # output latest folding profile
                  output_items[i][:] = self.folded[0]
              return len(output_items[0])
    comment: |-
      Fold

      Takes in a vector
      of samples and
      uses that as a time
      series, outputs
      resulting profile
      of folded time series

      May save overall
      profile (though this
      still needs to be
      fixed)
    nbins: '1024'
    nsamps: num_samples
    num_channels: channels
    num_inputs: channels - 2
    period: '0.0335'
    samp_rate: '1000000.0'
    save_external: 'True'
    savefile: ''''''
  states: {}
- name: gr_digital_rf_digital_rf_sink_1
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    channel1: ch1
    channel10: ch10
    channel11: ch11
    channel12: ch12
    channel13: ch13
    channel14: ch14
    channel15: ch15
    channel16: ch16
    channel17: ch17
    channel18: ch18
    channel19: ch19
    channel2: ch2
    channel20: ch20
    channel21: ch21
    channel22: ch22
    channel23: ch23
    channel24: ch24
    channel25: ch25
    channel26: ch26
    channel27: ch27
    channel28: ch28
    channel29: ch29
    channel3: ch3
    channel4: ch4
    channel5: ch5
    channel6: ch6
    channel7: ch7
    channel8: ch8
    channel9: ch9
    checksum: 'False'
    comment: Write/save data
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: f32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '30'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: save_dir
    uuid: ''
    vlen: '1024'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: '''misa-l'''
    channel1: '''misa-l2'''
    comment: Read data
    end0: ''
    end1: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '2'
    repeat: 'False'
    start0: ''
    start1: ''
    throttle: 'False'
    top_level_dir: source_dir
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import mitarspysigproc.filtertools as filter
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This flowgraph's
      configuration is
      specific to MISA
      data
    note: specific
  states: {}
- name: num_samples
  id: parameter
  parameters:
    type: intx
    value: '2048'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    comment: PFB
    nchans: channels
    osr: '1.0'
    taps: filter.kaiser_coeffs(channels)
  states: {}
- name: save_dir
  id: parameter
  parameters:
    type: str
    value: /path/to/save/data
  states: {}
- name: source_dir
  id: parameter
  parameters:
    comment: |-
      Top-level directory
      where Digital RF
      data is stored
    label: /path/to/source/data
    type: str
    value: '0'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0_10, '0', epy_block_0, '21']
- [blocks_stream_to_vector_0_11, '0', epy_block_0, '20']
- [blocks_stream_to_vector_0_12, '0', epy_block_0, '19']
- [blocks_stream_to_vector_0_13, '0', epy_block_0, '18']
- [blocks_stream_to_vector_0_14, '0', epy_block_0, '17']
- [blocks_stream_to_vector_0_15, '0', epy_block_0, '16']
- [blocks_stream_to_vector_0_16, '0', epy_block_0, '15']
- [blocks_stream_to_vector_0_17, '0', epy_block_0, '14']
- [blocks_stream_to_vector_0_18, '0', epy_block_0, '13']
- [blocks_stream_to_vector_0_19, '0', epy_block_0, '12']
- [blocks_stream_to_vector_0_2, '0', epy_block_0, '29']
- [blocks_stream_to_vector_0_20, '0', epy_block_0, '11']
- [blocks_stream_to_vector_0_21, '0', epy_block_0, '10']
- [blocks_stream_to_vector_0_22, '0', epy_block_0, '9']
- [blocks_stream_to_vector_0_23, '0', epy_block_0, '8']
- [blocks_stream_to_vector_0_24, '0', epy_block_0, '7']
- [blocks_stream_to_vector_0_25, '0', epy_block_0, '6']
- [blocks_stream_to_vector_0_26, '0', epy_block_0, '5']
- [blocks_stream_to_vector_0_27, '0', epy_block_0, '4']
- [blocks_stream_to_vector_0_28, '0', epy_block_0, '3']
- [blocks_stream_to_vector_0_29, '0', epy_block_0, '2']
- [blocks_stream_to_vector_0_3, '0', epy_block_0, '28']
- [blocks_stream_to_vector_0_30, '0', epy_block_0, '1']
- [blocks_stream_to_vector_0_4, '0', epy_block_0, '27']
- [blocks_stream_to_vector_0_5, '0', epy_block_0, '26']
- [blocks_stream_to_vector_0_6, '0', epy_block_0, '25']
- [blocks_stream_to_vector_0_7, '0', epy_block_0, '24']
- [blocks_stream_to_vector_0_8, '0', epy_block_0, '23']
- [blocks_stream_to_vector_0_9, '0', epy_block_0, '22']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_stream_to_vector_0_30, '0']
- [blocks_vector_to_streams_0, '10', blocks_stream_to_vector_0_21, '0']
- [blocks_vector_to_streams_0, '11', blocks_stream_to_vector_0_20, '0']
- [blocks_vector_to_streams_0, '12', blocks_stream_to_vector_0_19, '0']
- [blocks_vector_to_streams_0, '13', blocks_stream_to_vector_0_18, '0']
- [blocks_vector_to_streams_0, '14', blocks_stream_to_vector_0_17, '0']
- [blocks_vector_to_streams_0, '15', blocks_stream_to_vector_0_16, '0']
- [blocks_vector_to_streams_0, '16', blocks_stream_to_vector_0_15, '0']
- [blocks_vector_to_streams_0, '17', blocks_stream_to_vector_0_14, '0']
- [blocks_vector_to_streams_0, '18', blocks_stream_to_vector_0_13, '0']
- [blocks_vector_to_streams_0, '19', blocks_stream_to_vector_0_12, '0']
- [blocks_vector_to_streams_0, '2', blocks_stream_to_vector_0_29, '0']
- [blocks_vector_to_streams_0, '20', blocks_stream_to_vector_0_11, '0']
- [blocks_vector_to_streams_0, '21', blocks_stream_to_vector_0_10, '0']
- [blocks_vector_to_streams_0, '22', blocks_stream_to_vector_0_9, '0']
- [blocks_vector_to_streams_0, '23', blocks_stream_to_vector_0_8, '0']
- [blocks_vector_to_streams_0, '24', blocks_stream_to_vector_0_7, '0']
- [blocks_vector_to_streams_0, '25', blocks_stream_to_vector_0_6, '0']
- [blocks_vector_to_streams_0, '26', blocks_stream_to_vector_0_5, '0']
- [blocks_vector_to_streams_0, '27', blocks_stream_to_vector_0_4, '0']
- [blocks_vector_to_streams_0, '28', blocks_stream_to_vector_0_3, '0']
- [blocks_vector_to_streams_0, '29', blocks_stream_to_vector_0_2, '0']
- [blocks_vector_to_streams_0, '3', blocks_stream_to_vector_0_28, '0']
- [blocks_vector_to_streams_0, '4', blocks_stream_to_vector_0_27, '0']
- [blocks_vector_to_streams_0, '5', blocks_stream_to_vector_0_26, '0']
- [blocks_vector_to_streams_0, '6', blocks_stream_to_vector_0_25, '0']
- [blocks_vector_to_streams_0, '7', blocks_stream_to_vector_0_24, '0']
- [blocks_vector_to_streams_0, '8', blocks_stream_to_vector_0_23, '0']
- [blocks_vector_to_streams_0, '9', blocks_stream_to_vector_0_22, '0']
- [epy_block_0, '0', gr_digital_rf_digital_rf_sink_1, '0']
- [epy_block_0, '1', gr_digital_rf_digital_rf_sink_1, '1']
- [epy_block_0, '10', gr_digital_rf_digital_rf_sink_1, '10']
- [epy_block_0, '11', gr_digital_rf_digital_rf_sink_1, '11']
- [epy_block_0, '12', gr_digital_rf_digital_rf_sink_1, '12']
- [epy_block_0, '13', gr_digital_rf_digital_rf_sink_1, '13']
- [epy_block_0, '14', gr_digital_rf_digital_rf_sink_1, '14']
- [epy_block_0, '15', gr_digital_rf_digital_rf_sink_1, '15']
- [epy_block_0, '16', gr_digital_rf_digital_rf_sink_1, '16']
- [epy_block_0, '17', gr_digital_rf_digital_rf_sink_1, '17']
- [epy_block_0, '18', gr_digital_rf_digital_rf_sink_1, '18']
- [epy_block_0, '19', gr_digital_rf_digital_rf_sink_1, '19']
- [epy_block_0, '2', gr_digital_rf_digital_rf_sink_1, '2']
- [epy_block_0, '20', gr_digital_rf_digital_rf_sink_1, '20']
- [epy_block_0, '21', gr_digital_rf_digital_rf_sink_1, '21']
- [epy_block_0, '22', gr_digital_rf_digital_rf_sink_1, '22']
- [epy_block_0, '23', gr_digital_rf_digital_rf_sink_1, '23']
- [epy_block_0, '24', gr_digital_rf_digital_rf_sink_1, '24']
- [epy_block_0, '25', gr_digital_rf_digital_rf_sink_1, '25']
- [epy_block_0, '26', gr_digital_rf_digital_rf_sink_1, '26']
- [epy_block_0, '27', gr_digital_rf_digital_rf_sink_1, '27']
- [epy_block_0, '28', gr_digital_rf_digital_rf_sink_1, '28']
- [epy_block_0, '29', gr_digital_rf_digital_rf_sink_1, '29']
- [epy_block_0, '3', gr_digital_rf_digital_rf_sink_1, '3']
- [epy_block_0, '4', gr_digital_rf_digital_rf_sink_1, '4']
- [epy_block_0, '5', gr_digital_rf_digital_rf_sink_1, '5']
- [epy_block_0, '6', gr_digital_rf_digital_rf_sink_1, '6']
- [epy_block_0, '7', gr_digital_rf_digital_rf_sink_1, '7']
- [epy_block_0, '8', gr_digital_rf_digital_rf_sink_1, '8']
- [epy_block_0, '9', gr_digital_rf_digital_rf_sink_1, '9']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_null_sink_1, '0']
- [gr_digital_rf_digital_rf_source_0, '1', blocks_throttle_0, '0']
- [gr_digital_rf_digital_rf_source_0, properties, blocks_msgpair_to_var_0, inpair]
- [pfb_channelizer_ccf_0, '0', blocks_streams_to_vector_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_streams_to_vector_0, '1']
- [pfb_channelizer_ccf_0, '10', blocks_streams_to_vector_0, '10']
- [pfb_channelizer_ccf_0, '11', blocks_streams_to_vector_0, '11']
- [pfb_channelizer_ccf_0, '12', blocks_streams_to_vector_0, '12']
- [pfb_channelizer_ccf_0, '13', blocks_streams_to_vector_0, '13']
- [pfb_channelizer_ccf_0, '14', blocks_streams_to_vector_0, '14']
- [pfb_channelizer_ccf_0, '15', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '16', blocks_null_sink_0, '1']
- [pfb_channelizer_ccf_0, '17', blocks_streams_to_vector_0, '15']
- [pfb_channelizer_ccf_0, '18', blocks_streams_to_vector_0, '16']
- [pfb_channelizer_ccf_0, '19', blocks_streams_to_vector_0, '17']
- [pfb_channelizer_ccf_0, '2', blocks_streams_to_vector_0, '2']
- [pfb_channelizer_ccf_0, '20', blocks_streams_to_vector_0, '18']
- [pfb_channelizer_ccf_0, '21', blocks_streams_to_vector_0, '19']
- [pfb_channelizer_ccf_0, '22', blocks_streams_to_vector_0, '20']
- [pfb_channelizer_ccf_0, '23', blocks_streams_to_vector_0, '21']
- [pfb_channelizer_ccf_0, '24', blocks_streams_to_vector_0, '22']
- [pfb_channelizer_ccf_0, '25', blocks_streams_to_vector_0, '23']
- [pfb_channelizer_ccf_0, '26', blocks_streams_to_vector_0, '24']
- [pfb_channelizer_ccf_0, '27', blocks_streams_to_vector_0, '25']
- [pfb_channelizer_ccf_0, '28', blocks_streams_to_vector_0, '26']
- [pfb_channelizer_ccf_0, '29', blocks_streams_to_vector_0, '27']
- [pfb_channelizer_ccf_0, '3', blocks_streams_to_vector_0, '3']
- [pfb_channelizer_ccf_0, '30', blocks_streams_to_vector_0, '28']
- [pfb_channelizer_ccf_0, '31', blocks_streams_to_vector_0, '29']
- [pfb_channelizer_ccf_0, '4', blocks_streams_to_vector_0, '4']
- [pfb_channelizer_ccf_0, '5', blocks_streams_to_vector_0, '5']
- [pfb_channelizer_ccf_0, '6', blocks_streams_to_vector_0, '6']
- [pfb_channelizer_ccf_0, '7', blocks_streams_to_vector_0, '7']
- [pfb_channelizer_ccf_0, '8', blocks_streams_to_vector_0, '8']
- [pfb_channelizer_ccf_0, '9', blocks_streams_to_vector_0, '9']

metadata:
  file_format: 1
