options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: buffermemory_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '24000000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Buffer error is caused
      by making vectors too
      long (ie., 120M samples
      in a vector overflows
      buffer).

      Therefore, I must find a
      way to fold time series
      in chunks... (2 min is
      120M samples, so...)
    note: what causes error
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      FAILS:
      	120M (2 min)
      	60M (1 min)
      	30M (30 sec)
      	25M (25 sec)

      SUCCEEDS:
      	10M (10 sec)
      	15M (15 sec)
      	20M (20 sec)
      	24M (24 sec)

      Note: this is only true for 
      having a single stream to
      vector (multiple vectors
      require more space)

      Num vectors proportional
      to buffer space taken (1 vec
      at 24M is same as 3 vecs at
      8M).

      Also note: I suspect buffers
      are system-specific.
    note: max buffer (vec lengths)
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_null_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_null_source_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
