options:
  parameters:
    generate_options: hb
    id: pulsar_hier
    output_language: python
    title: Pulsar Processing Hier Block
  states: {}

blocks:
- name: points
  id: variable
  parameters:
    comment: Points to fold
    value: int(per * 5 * samp_rate)
  states: {}
- name: bins
  id: parameter
  parameters:
    comment: '# of bins for folding'
    label: Number of Folding Bins
    type: intx
    value: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Convert signal to power
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: points
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import psrdynspec
      from psrdynspec import fold

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          samps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, samp_rate=1000000, Nbins=1024, pfold=33.5028583*1e-3):

              samps = 167514  # number of "samples" (resampled) that ultimately get processed
              self.nsamps = samps

              gr.sync_block.__init__(
                  self,
                  name='Folding',   # will show up in GRC
                  in_sig=[(np.float32, samps)],
                  out_sig=[(np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold
              
              self.times = np.arange(self.nsamps)/samp_rate

              self.timeseries = np.array

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold.fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = np.nan_to_num(self.profile)
              return len(output_items[0])
    comment: |-
      Note: embedded
      Python blocks can't
      have variable input
      length.

      Always takes in
      vector of length
      30,000,000 (30
      seconds at 1MHz
      sample rate)
    pfold: per
    samp_rate: samp_rate
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    comment: y-axis (power)
    label: profile
    type: float
    vlen: bins
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    comment: |-
      Takes in the
      single channel
      of data from
      PFB ("single"
      frequency)
    label: in
    type: complex
  states: {}
- name: per
  id: parameter
  parameters:
    comment: |-
      Folding period (also
      period of pulsar)
    label: Period (s)
    type: eng_float
    value: '0.0335028583'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Resamples to make
      integration over any time
      period (theoretically)
      possible.
    decim: (time * samp_rate)
    interp: points
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    comment: Sample rate
    label: Sample Rate (sps)
    type: eng_float
    value: '1000000'
  states: {}
- name: time
  id: parameter
  parameters:
    comment: |-
      Number of seconds
      to fold over.
    label: Integration Time (s)
    type: intx
    value: '60'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', rational_resampler_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [epy_block_0, '0', pad_sink_0_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
