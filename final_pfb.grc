options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: final_pfb
    output_language: python
    title: 'Prototype Flowgraph: PFB'
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 440e6
  states: {}
- name: channel
  id: variable
  parameters:
    comment: |-
      Channel
      name
    value: '''ch0'''
  states: {}
- name: data_dir
  id: variable
  parameters:
    comment: |-
      Top level directory for stored
      DRF data
    value: '"C:\\Users\\vlpannel\\Desktop\\SRT\\raw"'
  states: {}
- name: num_subchannels
  id: variable
  parameters:
    comment: |-
      Number of subchannels
      in channel
    value: '2'
  states: {}
- name: pfb_channels
  id: variable
  parameters:
    comment: |-
      This can probably
      be a fixed value for
      SRT (fixed
      bandwidth and
      setup).
    value: '31'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sink_file
  id: variable
  parameters:
    value: '"C:\\Users\\vlpannel\\Desktop\\SRT\\pfb"'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_msg_meta_to_pair_0
  id: blocks_msg_meta_to_pair
  parameters:
    keyin: key in
    keyout: key out
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: property
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: |-
      Remove
      channels
      at edge of
      bandwidth
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Controlling flow (no hardware here)
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: num_subchannels
    type: short
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[center_freq]'
    channel0: ch0
    channel1: ch1
    channel10: ch10
    channel11: ch11
    channel12: ch12
    channel13: ch13
    channel14: ch14
    channel15: ch15
    channel16: ch16
    channel17: ch17
    channel18: ch18
    channel19: ch19
    channel2: ch2
    channel20: ch20
    channel21: ch21
    channel22: ch22
    channel23: ch23
    channel24: ch24
    channel25: ch25
    channel26: ch26
    channel27: ch27
    channel28: ch28
    channel3: ch3
    channel4: ch4
    channel5: ch5
    channel6: ch6
    channel7: ch7
    channel8: ch8
    channel9: ch9
    checksum: 'False'
    comment: |-
      Storing complex32s

      Remember PFB
      mapping!
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'False'
    marching_periods: 'True'
    metadata: '{property}'
    min_chunksize: '0'
    nchan: int(2 * (pfb_channels // 2) - 1)
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: sink_file
    uuid: ''
    vlen: '1'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: channel
    end0: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'True'
    top_level_dir: data_dir
  states: {}
- name: kaiser_taps
  id: epy_module
  parameters:
    comment: |-
      Taps (coeffs) for
      Kaiser windowing
    source_code: |
      import mitarspysigproc.filtertools as ft
      import numpy as np

      x = 5 # FOR DEBUG

      def taps(chans):
          """
          Returns PFB taps for Kaiser windowing using filtertools.

          Parameters
          ----------
          chans : int
              Number of channels that PFB will yield

          Returns
          -------
          taps : vector
              Filter taps for PFB as a real vector
          """
          taps = np.reshape(ft.kaiser_coeffs(chans), -1)
          return taps
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Remember to pay attention
      to connections here if
      subchannels change!
    note: Subchannels change
  states: {}
- name: note_2
  id: note
  parameters:
    note: DRF Source related
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      Remember to alter data types
      if file outputs different type!
    note: Assumes IShort (c8)
  states: {}
- name: pfb_channelizer_ccf_1
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: |-
      Channel 0 (out0) is at
      center frequency
    nchans: pfb_channels
    osr: '1.0'
    taps: kaiser_taps.taps(pfb_channels)
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      For debug purposes.

      Should see high freqs
      peaking before low 
      freqs (dispersion).
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      # loop to connect PFB to DRF Sink
      # this cuts out edge of bandwidth channels
      for c in range(pfb_channels):  #FIX ME (if faster code needed)
      	
      	# initial half of channels
      	if c < pfb_channels // 2:
      		self.connect((self.pfb_channelizer_ccf_0, c), (self.gr_digital_rf_digital_rf_sink_0, c))
      	
      	# second half of channels
      	if c > ((pfb_channels // 2) + (pfb_channels % 2)):
      		self.connect((self.pfb_channelizer_ccf_0, c), (self.gr_digital_rf_digital_rf_sink_0, c - (pfb_channels % 2) - 1))
    comment: |-
      This code may come in handy when PFB
      channels change; connects each PFB out
      to a DRF in.
    priority: '1000'
    section: main_after_init
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: metadata
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      FIX ME: this is the beginning of transferring DRF
      metadata from original file to next file. Save all
      properties as variables with this chain (may use
      embedded Python block to do this instead later).
    stream_id: metadata
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', pfb_channelizer_ccf_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_msg_meta_to_pair_0, outpair, blocks_msgpair_to_var_0, inpair]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_vector_to_streams_0, '0']
- [gr_digital_rf_digital_rf_source_0, properties, virtual_sink_0, '0']
- [pfb_channelizer_ccf_1, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [pfb_channelizer_ccf_1, '1', gr_digital_rf_digital_rf_sink_0, '1']
- [pfb_channelizer_ccf_1, '10', gr_digital_rf_digital_rf_sink_0, '10']
- [pfb_channelizer_ccf_1, '11', gr_digital_rf_digital_rf_sink_0, '11']
- [pfb_channelizer_ccf_1, '12', gr_digital_rf_digital_rf_sink_0, '12']
- [pfb_channelizer_ccf_1, '13', gr_digital_rf_digital_rf_sink_0, '13']
- [pfb_channelizer_ccf_1, '14', gr_digital_rf_digital_rf_sink_0, '14']
- [pfb_channelizer_ccf_1, '15', blocks_null_sink_1, '0']
- [pfb_channelizer_ccf_1, '16', blocks_null_sink_1, '1']
- [pfb_channelizer_ccf_1, '17', gr_digital_rf_digital_rf_sink_0, '15']
- [pfb_channelizer_ccf_1, '18', gr_digital_rf_digital_rf_sink_0, '16']
- [pfb_channelizer_ccf_1, '19', gr_digital_rf_digital_rf_sink_0, '17']
- [pfb_channelizer_ccf_1, '2', gr_digital_rf_digital_rf_sink_0, '2']
- [pfb_channelizer_ccf_1, '20', gr_digital_rf_digital_rf_sink_0, '18']
- [pfb_channelizer_ccf_1, '21', gr_digital_rf_digital_rf_sink_0, '19']
- [pfb_channelizer_ccf_1, '22', gr_digital_rf_digital_rf_sink_0, '20']
- [pfb_channelizer_ccf_1, '23', gr_digital_rf_digital_rf_sink_0, '21']
- [pfb_channelizer_ccf_1, '24', gr_digital_rf_digital_rf_sink_0, '22']
- [pfb_channelizer_ccf_1, '25', gr_digital_rf_digital_rf_sink_0, '23']
- [pfb_channelizer_ccf_1, '26', gr_digital_rf_digital_rf_sink_0, '24']
- [pfb_channelizer_ccf_1, '27', gr_digital_rf_digital_rf_sink_0, '25']
- [pfb_channelizer_ccf_1, '28', gr_digital_rf_digital_rf_sink_0, '26']
- [pfb_channelizer_ccf_1, '29', gr_digital_rf_digital_rf_sink_0, '27']
- [pfb_channelizer_ccf_1, '3', gr_digital_rf_digital_rf_sink_0, '3']
- [pfb_channelizer_ccf_1, '30', gr_digital_rf_digital_rf_sink_0, '28']
- [pfb_channelizer_ccf_1, '4', gr_digital_rf_digital_rf_sink_0, '4']
- [pfb_channelizer_ccf_1, '5', gr_digital_rf_digital_rf_sink_0, '5']
- [pfb_channelizer_ccf_1, '6', gr_digital_rf_digital_rf_sink_0, '6']
- [pfb_channelizer_ccf_1, '7', gr_digital_rf_digital_rf_sink_0, '7']
- [pfb_channelizer_ccf_1, '8', gr_digital_rf_digital_rf_sink_0, '8']
- [pfb_channelizer_ccf_1, '9', gr_digital_rf_digital_rf_sink_0, '9']
- [virtual_source_0, '0', blocks_msg_meta_to_pair_0, inmeta]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
