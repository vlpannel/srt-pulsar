options:
  parameters:
    author: Viveca Pannell
    description: Pulsar processing for Small Radio Telesope; combination version (various options).
    generate_options: qt_gui
    id: pulsar_combination
    output_language: python
    title: pulsar_combination
  states: {}

blocks:
- name: baseline_time
  id: parameter
  parameters:
    type: eng_float
    value: '30.'
  states: {}
- name: bins
  id: parameter
  parameters:
    type: intx
    value: '1024'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '32'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_10
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_11
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_12
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_13
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_14
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_15
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_16
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_17
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_18
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_19
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_20
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_21
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_22
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_23
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_24
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_25
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_26
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_27
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_28
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_29
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_30
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_4
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_5
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_6
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_7
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_8
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_9
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 0, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 1, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 2, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_10
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32,11, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_11
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 12, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_12
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 13, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_13
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 14, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 15, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 17, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_1
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 18, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_10
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 27, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_11
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 28, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_12
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 29, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_13
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 30, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_14
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 31, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_2
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 19, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_3
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 20, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_4
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 21, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_5
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 22, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_6
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 23, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_7
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 24, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_8
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 25, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_9
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 26, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_15
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 16, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 3, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 4, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 5, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 6, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 7, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_7
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 8, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_8
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 9, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_9
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(440, 1, 32, 10, 56.77118, samp_rate/32)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data_sink
    type: float
    vlen: bins
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: data_source
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: data_source_selector
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: pfb_block_selector
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: pfb_block_selector
    num_inputs: '2'
    num_outputs: '4'
    output_index: output_selector
    type: float
    vlen: bins
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("strobe")
    nsamps: bins
    type: float
    value: pmt.intern("NEW PROFILE")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: bins
    type: float
  states: {}
- name: data_sink
  id: parameter
  parameters:
    type: str
    value: /path/to/data/file
  states: {}
- name: data_source
  id: parameter
  parameters:
    type: str
    value: /absolute/path/to/data
  states: {}
- name: data_source_selector
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: deviations
  id: parameter
  parameters:
    type: eng_float
    value: '10'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_10
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_11
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_12
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_13
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_10
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_11
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_12
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_13
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_14
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_6
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_7
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_8
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_9
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_15
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_6
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_7
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_8
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_9
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=0.0333924123 , samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              Always outputs the last calculated phase vs. power profile.

              After calculating, immediately begins collecting data for a new calculation.
              
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enough data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: integration_time
    period: period
    samp_rate: samp_rate / num_channels
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=0.0333924123 , samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              Always outputs the last calculated phase vs. power profile.

              After calculating, immediately begins collecting data for a new calculation.
              
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enough data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: integration_time
    period: period
    samp_rate: samp_rate / num_channels
  states: {}
- name: filter_taps
  id: parameter
  parameters:
    value: filtertools.kaiser_coeffs(num_channels)
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: data_source
    end: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'False'
    start: ''
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: f32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: data_sink
    uuid: ''
    vlen: bins
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import mitarspysigproc.filtertools as filtertools
  states: {}
- name: inco_dedisp
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\ndef dedisperse(center_freq, bandwidth, num_channels, channel, dm, samp_rate):\n    '''\n    Delay channel be specified amount given frequencies and dispersion measure. Assumes standard channel mapping and even number of channels. Aligns all channels with lowest channel (for delay purposes).\n\n    Parameters\n    ----------\n\n    center_freq : float\n        Center frequency in MHz\n\n    bandwidth : float\n        Total bandwidth of signal reception in MHz\n\n    num_channels : int\n        Number of channels into which bandwidth is divided (equally)\n\n    channel : int\n        Which channel is being dedispersed (0 is at center frequency)\n\n    dm : float\n        Dispersion measure of pulsar\n\n    samp_rate : float\n        Sample rate of incoming samples (samples per second)\n    '''\n\n    kdm = 4.149 * 1000    # dispersion measure constant (converted from GHz^2 to MHz^2 and ms to s)\n\n    # find frequencies of lowest channel and current channel\n    channel_width = bandwidth / num_channels\n    v2 = center_freq - (bandwidth/2)     # lowest frequency\n    if channel <= num_channels/2:       # current channel\n        v1 = center_freq + (channel)*channel_width\n    else:\n        v1 = center_freq - (num_channels - channel)*channel_width\n\n    # find amount of dispersion\n    time_delta = kdm * dm * ((1/(v2**2)) - (1/(v1**2)))\n    return int(time_delta * samp_rate)\n    \n"
  states: {}
- name: integration_time
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: num_channels
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: data_source
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: output_selector
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: period
  id: parameter
  parameters:
    type: eng_float
    value: '0.0333924123 '
  states: {}
- name: pfb_block_selector
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: '32'
    osr: '1.0'
    taps: filter_taps
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: num_channels
    taps: filter_taps
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '1000000'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: data_source
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_1, '0', epy_block_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', epy_block_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', epy_block_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_1, '0', epy_block_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_0_10, '0', epy_block_0_0_10, '0']
- [blocks_complex_to_mag_squared_0_0_11, '0', epy_block_0_0_11, '0']
- [blocks_complex_to_mag_squared_0_0_12, '0', epy_block_0_0_12, '0']
- [blocks_complex_to_mag_squared_0_0_13, '0', epy_block_0_0_13, '0']
- [blocks_complex_to_mag_squared_0_0_14, '0', epy_block_0_0_14, '0']
- [blocks_complex_to_mag_squared_0_0_15, '0', epy_block_0_0_15, '0']
- [blocks_complex_to_mag_squared_0_0_16, '0', epy_block_0_0_14_0, '0']
- [blocks_complex_to_mag_squared_0_0_17, '0', epy_block_0_0_14_1, '0']
- [blocks_complex_to_mag_squared_0_0_18, '0', epy_block_0_0_14_2, '0']
- [blocks_complex_to_mag_squared_0_0_19, '0', epy_block_0_0_14_3, '0']
- [blocks_complex_to_mag_squared_0_0_2, '0', epy_block_0_0_2, '0']
- [blocks_complex_to_mag_squared_0_0_20, '0', epy_block_0_0_14_4, '0']
- [blocks_complex_to_mag_squared_0_0_21, '0', epy_block_0_0_14_5, '0']
- [blocks_complex_to_mag_squared_0_0_22, '0', epy_block_0_0_14_6, '0']
- [blocks_complex_to_mag_squared_0_0_23, '0', epy_block_0_0_14_7, '0']
- [blocks_complex_to_mag_squared_0_0_24, '0', epy_block_0_0_14_8, '0']
- [blocks_complex_to_mag_squared_0_0_25, '0', epy_block_0_0_14_9, '0']
- [blocks_complex_to_mag_squared_0_0_26, '0', epy_block_0_0_14_10, '0']
- [blocks_complex_to_mag_squared_0_0_27, '0', epy_block_0_0_14_11, '0']
- [blocks_complex_to_mag_squared_0_0_28, '0', epy_block_0_0_14_12, '0']
- [blocks_complex_to_mag_squared_0_0_29, '0', epy_block_0_0_14_13, '0']
- [blocks_complex_to_mag_squared_0_0_3, '0', epy_block_0_0_3, '0']
- [blocks_complex_to_mag_squared_0_0_30, '0', epy_block_0_0_14_14, '0']
- [blocks_complex_to_mag_squared_0_0_4, '0', epy_block_0_0_4, '0']
- [blocks_complex_to_mag_squared_0_0_5, '0', epy_block_0_0_5, '0']
- [blocks_complex_to_mag_squared_0_0_6, '0', epy_block_0_0_6, '0']
- [blocks_complex_to_mag_squared_0_0_7, '0', epy_block_0_0_7, '0']
- [blocks_complex_to_mag_squared_0_0_8, '0', epy_block_0_0_8, '0']
- [blocks_complex_to_mag_squared_0_0_9, '0', epy_block_0_0_9, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_1, '1']
- [blocks_delay_0_1, '0', blocks_add_xx_1, '2']
- [blocks_delay_0_10, '0', blocks_add_xx_1, '11']
- [blocks_delay_0_11, '0', blocks_add_xx_1, '12']
- [blocks_delay_0_12, '0', blocks_add_xx_1, '13']
- [blocks_delay_0_13, '0', blocks_add_xx_1, '14']
- [blocks_delay_0_14, '0', blocks_add_xx_1, '15']
- [blocks_delay_0_14_0, '0', blocks_add_xx_1, '17']
- [blocks_delay_0_14_1, '0', blocks_add_xx_1, '18']
- [blocks_delay_0_14_10, '0', blocks_add_xx_1, '27']
- [blocks_delay_0_14_11, '0', blocks_add_xx_1, '28']
- [blocks_delay_0_14_12, '0', blocks_add_xx_1, '29']
- [blocks_delay_0_14_13, '0', blocks_add_xx_1, '30']
- [blocks_delay_0_14_14, '0', blocks_add_xx_1, '31']
- [blocks_delay_0_14_2, '0', blocks_add_xx_1, '19']
- [blocks_delay_0_14_3, '0', blocks_add_xx_1, '20']
- [blocks_delay_0_14_4, '0', blocks_add_xx_1, '21']
- [blocks_delay_0_14_5, '0', blocks_add_xx_1, '22']
- [blocks_delay_0_14_6, '0', blocks_add_xx_1, '23']
- [blocks_delay_0_14_7, '0', blocks_add_xx_1, '24']
- [blocks_delay_0_14_8, '0', blocks_add_xx_1, '25']
- [blocks_delay_0_14_9, '0', blocks_add_xx_1, '26']
- [blocks_delay_0_15, '0', blocks_add_xx_1, '16']
- [blocks_delay_0_2, '0', blocks_add_xx_1, '3']
- [blocks_delay_0_3, '0', blocks_add_xx_1, '4']
- [blocks_delay_0_4, '0', blocks_add_xx_1, '5']
- [blocks_delay_0_5, '0', blocks_add_xx_1, '6']
- [blocks_delay_0_6, '0', blocks_add_xx_1, '7']
- [blocks_delay_0_7, '0', blocks_add_xx_1, '8']
- [blocks_delay_0_8, '0', blocks_add_xx_1, '9']
- [blocks_delay_0_9, '0', blocks_add_xx_1, '10']
- [blocks_file_source_0, '0', blocks_selector_0, '3']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_selector_1, '0', pfb_decimator_ccf_0, '0']
- [blocks_selector_1, '1', pfb_channelizer_ccf_0, '0']
- [blocks_selector_2, '0', qtgui_vector_sink_f_0, '0']
- [blocks_selector_2, '1', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_selector_2, '2', blocks_file_sink_0, '0']
- [blocks_selector_2, '3', blocks_vector_to_stream_0, '0']
- [blocks_tags_strobe_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', blocks_selector_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_add_xx_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0_0, '0', blocks_delay_0, '0']
- [epy_block_0_0_0, '0', blocks_delay_0_0, '0']
- [epy_block_0_0_1, '0', blocks_delay_0_1, '0']
- [epy_block_0_0_10, '0', blocks_delay_0_10, '0']
- [epy_block_0_0_11, '0', blocks_delay_0_11, '0']
- [epy_block_0_0_12, '0', blocks_delay_0_12, '0']
- [epy_block_0_0_13, '0', blocks_delay_0_13, '0']
- [epy_block_0_0_14, '0', blocks_delay_0_14, '0']
- [epy_block_0_0_14_0, '0', blocks_delay_0_14_0, '0']
- [epy_block_0_0_14_1, '0', blocks_delay_0_14_1, '0']
- [epy_block_0_0_14_10, '0', blocks_delay_0_14_10, '0']
- [epy_block_0_0_14_11, '0', blocks_delay_0_14_11, '0']
- [epy_block_0_0_14_12, '0', blocks_delay_0_14_12, '0']
- [epy_block_0_0_14_13, '0', blocks_delay_0_14_13, '0']
- [epy_block_0_0_14_14, '0', blocks_delay_0_14_14, '0']
- [epy_block_0_0_14_2, '0', blocks_delay_0_14_2, '0']
- [epy_block_0_0_14_3, '0', blocks_delay_0_14_3, '0']
- [epy_block_0_0_14_4, '0', blocks_delay_0_14_4, '0']
- [epy_block_0_0_14_5, '0', blocks_delay_0_14_5, '0']
- [epy_block_0_0_14_6, '0', blocks_delay_0_14_6, '0']
- [epy_block_0_0_14_7, '0', blocks_delay_0_14_7, '0']
- [epy_block_0_0_14_8, '0', blocks_delay_0_14_8, '0']
- [epy_block_0_0_14_9, '0', blocks_delay_0_14_9, '0']
- [epy_block_0_0_15, '0', blocks_delay_0_15, '0']
- [epy_block_0_0_2, '0', blocks_delay_0_2, '0']
- [epy_block_0_0_3, '0', blocks_delay_0_3, '0']
- [epy_block_0_0_4, '0', blocks_delay_0_4, '0']
- [epy_block_0_0_5, '0', blocks_delay_0_5, '0']
- [epy_block_0_0_6, '0', blocks_delay_0_6, '0']
- [epy_block_0_0_7, '0', blocks_delay_0_7, '0']
- [epy_block_0_0_8, '0', blocks_delay_0_8, '0']
- [epy_block_0_0_9, '0', blocks_delay_0_9, '0']
- [epy_block_1, '0', blocks_selector_2, '0']
- [epy_block_1_0, '0', blocks_selector_2, '1']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_selector_0, '0']
- [osmosdr_source_0, '0', blocks_selector_0, '2']
- [pfb_channelizer_ccf_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_complex_to_mag_squared_0_0_0, '0']
- [pfb_channelizer_ccf_0, '10', blocks_complex_to_mag_squared_0_0_9, '0']
- [pfb_channelizer_ccf_0, '11', blocks_complex_to_mag_squared_0_0_10, '0']
- [pfb_channelizer_ccf_0, '12', blocks_complex_to_mag_squared_0_0_11, '0']
- [pfb_channelizer_ccf_0, '13', blocks_complex_to_mag_squared_0_0_12, '0']
- [pfb_channelizer_ccf_0, '14', blocks_complex_to_mag_squared_0_0_13, '0']
- [pfb_channelizer_ccf_0, '15', blocks_complex_to_mag_squared_0_0_14, '0']
- [pfb_channelizer_ccf_0, '16', blocks_complex_to_mag_squared_0_0_15, '0']
- [pfb_channelizer_ccf_0, '17', blocks_complex_to_mag_squared_0_0_16, '0']
- [pfb_channelizer_ccf_0, '18', blocks_complex_to_mag_squared_0_0_17, '0']
- [pfb_channelizer_ccf_0, '19', blocks_complex_to_mag_squared_0_0_18, '0']
- [pfb_channelizer_ccf_0, '2', blocks_complex_to_mag_squared_0_0_1, '0']
- [pfb_channelizer_ccf_0, '20', blocks_complex_to_mag_squared_0_0_19, '0']
- [pfb_channelizer_ccf_0, '21', blocks_complex_to_mag_squared_0_0_20, '0']
- [pfb_channelizer_ccf_0, '22', blocks_complex_to_mag_squared_0_0_21, '0']
- [pfb_channelizer_ccf_0, '23', blocks_complex_to_mag_squared_0_0_22, '0']
- [pfb_channelizer_ccf_0, '24', blocks_complex_to_mag_squared_0_0_23, '0']
- [pfb_channelizer_ccf_0, '25', blocks_complex_to_mag_squared_0_0_24, '0']
- [pfb_channelizer_ccf_0, '26', blocks_complex_to_mag_squared_0_0_25, '0']
- [pfb_channelizer_ccf_0, '27', blocks_complex_to_mag_squared_0_0_26, '0']
- [pfb_channelizer_ccf_0, '28', blocks_complex_to_mag_squared_0_0_27, '0']
- [pfb_channelizer_ccf_0, '29', blocks_complex_to_mag_squared_0_0_28, '0']
- [pfb_channelizer_ccf_0, '3', blocks_complex_to_mag_squared_0_0_2, '0']
- [pfb_channelizer_ccf_0, '30', blocks_complex_to_mag_squared_0_0_29, '0']
- [pfb_channelizer_ccf_0, '31', blocks_complex_to_mag_squared_0_0_30, '0']
- [pfb_channelizer_ccf_0, '4', blocks_complex_to_mag_squared_0_0_3, '0']
- [pfb_channelizer_ccf_0, '5', blocks_complex_to_mag_squared_0_0_4, '0']
- [pfb_channelizer_ccf_0, '6', blocks_complex_to_mag_squared_0_0_5, '0']
- [pfb_channelizer_ccf_0, '7', blocks_complex_to_mag_squared_0_0_6, '0']
- [pfb_channelizer_ccf_0, '8', blocks_complex_to_mag_squared_0_0_7, '0']
- [pfb_channelizer_ccf_0, '9', blocks_complex_to_mag_squared_0_0_8, '0']
- [pfb_decimator_ccf_0, '0', blocks_complex_to_mag_squared_0, '0']
- [zeromq_sub_source_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
