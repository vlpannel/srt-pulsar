options:
  parameters:
    author: vivecapannell
    generate_options: qt_gui
    id: test_foldingblock
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: source_file
  id: variable
  parameters:
    value: '''/Users/vivecapannell/Desktop/pulsar_binary/misa-l2_pfb/ch21'''
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '31'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate **2
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: np.load('/Users/vivecapannell/Desktop/pulsar_binary/misa-l2.npy')
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              def fold_ts(timeseries, times, pfold, Nbins, return_counts=False):  # hard encoded b/c this machine can't import psrdynspec
                  phi = times/pfold % 1.0
                  phibin_edges = np.linspace(0.,1.,Nbins+1) # Edges of phase bins
                  phibin_centers = 0.5*(phibin_edges[1:]+phibin_edges[:-1]) # Centers of phase bins
                  indbin_edges = np.digitize(phi,phibin_edges,right=True) # Place phase values in phase bins. Returns indices of placement in phase bins array.
                  # Given edges x < y, a phase bin is defined to be the range (x,y].

                  # Arrays to store profile and counts per phase bin.
                  profile = np.zeros(Nbins)
                  counts = np.zeros(Nbins)
                  for n in range(1,Nbins+1):
                      profile[n-1] = np.sum(timeseries[np.where(indbin_edges==n)]) # Sum up time series flux values that fall in one phase bin.
                      counts[n-1] = np.size(np.where(indbin_edges==n)) # No. of counts in bin.
                  profile /= counts # Divide by the number of counts to generate an average profile.
                  if return_counts:
                      return profile, phibin_centers, counts
                  else:
                      return profile, phibin_centers
              self.fold_ts = fold_ts

          def work(self, input_items, output_items):

              self.data = np.append(self.data, input_items[0])
              '''
              if self.data.size % 100 == 0:
                  print(f'{self.data.size} samples collected')
              '''

              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)
              
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: '30'
    period: '.0335028583'
    samp_rate: samp_rate/32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: '32'
    osr: '1.0'
    taps: np.load('/Users/vivecapannell/Desktop/pulsar_binary/kaiser_coeffs.npy')
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', epy_block_1, '0']
- [blocks_throttle_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [epy_block_1, '0', qtgui_vector_sink_f_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_null_sink_0, '1']
- [pfb_channelizer_ccf_0, '10', blocks_null_sink_0, '10']
- [pfb_channelizer_ccf_0, '11', blocks_null_sink_0, '11']
- [pfb_channelizer_ccf_0, '12', blocks_null_sink_0, '12']
- [pfb_channelizer_ccf_0, '13', blocks_null_sink_0, '13']
- [pfb_channelizer_ccf_0, '14', blocks_null_sink_0, '14']
- [pfb_channelizer_ccf_0, '15', blocks_null_sink_0, '15']
- [pfb_channelizer_ccf_0, '16', blocks_null_sink_0, '16']
- [pfb_channelizer_ccf_0, '17', blocks_null_sink_0, '17']
- [pfb_channelizer_ccf_0, '18', blocks_null_sink_0, '18']
- [pfb_channelizer_ccf_0, '19', blocks_null_sink_0, '19']
- [pfb_channelizer_ccf_0, '2', blocks_null_sink_0, '2']
- [pfb_channelizer_ccf_0, '20', blocks_null_sink_0, '20']
- [pfb_channelizer_ccf_0, '21', blocks_complex_to_mag_squared_0, '0']
- [pfb_channelizer_ccf_0, '22', blocks_null_sink_0, '22']
- [pfb_channelizer_ccf_0, '23', blocks_null_sink_0, '23']
- [pfb_channelizer_ccf_0, '24', blocks_null_sink_0, '24']
- [pfb_channelizer_ccf_0, '25', blocks_null_sink_0, '25']
- [pfb_channelizer_ccf_0, '26', blocks_null_sink_0, '26']
- [pfb_channelizer_ccf_0, '27', blocks_null_sink_0, '27']
- [pfb_channelizer_ccf_0, '28', blocks_null_sink_0, '28']
- [pfb_channelizer_ccf_0, '29', blocks_null_sink_0, '29']
- [pfb_channelizer_ccf_0, '3', blocks_null_sink_0, '3']
- [pfb_channelizer_ccf_0, '30', blocks_null_sink_0, '30']
- [pfb_channelizer_ccf_0, '31', blocks_null_sink_0, '21']
- [pfb_channelizer_ccf_0, '4', blocks_null_sink_0, '4']
- [pfb_channelizer_ccf_0, '5', blocks_null_sink_0, '5']
- [pfb_channelizer_ccf_0, '6', blocks_null_sink_0, '6']
- [pfb_channelizer_ccf_0, '7', blocks_null_sink_0, '7']
- [pfb_channelizer_ccf_0, '8', blocks_null_sink_0, '8']
- [pfb_channelizer_ccf_0, '9', blocks_null_sink_0, '9']

metadata:
  file_format: 1
