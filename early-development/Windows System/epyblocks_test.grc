options:
  parameters:
    author: vlpannel
    generate_options: qt_gui
    id: epyblocks_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '31'
    value: '21'
  states: {}
- name: dev
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: filt_time
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '120'
    value: '10'
  states: {}
- name: period
  id: variable
  parameters:
    value: '.0335028583'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: time
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '120'
    value: '60'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\unfiltered
    type: float
    vlen: '1024'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\filtered
    type: float
    vlen: '1024'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("strobe")
    nsamps: '100000'
    type: float
    value: pmt.intern("TAG")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate * 10000000000
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[100,2,3,4,5,600,7,8,9,10] * 10 + [100] * 5'
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0] * 975 + [10] * 25'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from __future__ import absolute_import, division, print_function

      import os
      import traceback

      import gnuradio.blocks
      import h5py
      import pmt
      import six


      import numpy as np
      from gnuradio import gr
      import digital_rf as drf
      from digital_rf import DigitalRFReader, util


      class mod_drf_blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Modified version of DRF Source"""

          def __init__(self, data_dir=r'E:\pulsar\2022-05-26\usrp-rx0-r_20220526T200000_20220526T210800\rf_data', chan='misa-l2', repeat=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Modified DRF Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              self.data_dir = data_dir
              self.chan = chan
              self.repeat = repeat    # repeat flag: currently nonfunctional, but may be useful later
              
              self.do = drf.DigitalRFReader(self.data_dir)
              self.bounds = self.do.get_bounds(self.chan)
              self.prop = self.do.get_properties(self.chan)
              
              self.index = self.bounds[0]# + (16 * 1000000)     # start at first sample
              self.result = 0
              
          def work(self, input_items, output_items):
              out = output_items[0]
              nsamples = len(out)
              data = self.do.read_vector(self.index, nsamples, self.chan)
              self.index += nsamples
              
              output_items[0][:] = data
              
              return len(output_items[0])
          '''
          def work(self, input_items, output_items):
              #ADDED CONTENT
              self._start_sample = util.parse_identifier_to_sample(
                  None, self.prop["samples_per_second"], self.bounds[0]
              )
              self._end_sample = util.parse_identifier_to_sample(
                  None, self.prop["samples_per_second"], self.bounds[0]
              )
              self._gapless = True
              if self._start_sample is None:
                  self._read_start_sample = self.bounds[0]
              else:
                  self._read_start_sample = self._start_sample
              
              out = output_items[0]
              nsamples = len(out)
              next_index = 0
              # repeat reading until we succeed or return
              while next_index < nsamples:
                  read_start = self._read_start_sample
                  # read_end is inclusive, hence the -1
                  read_end = self._read_start_sample + (nsamples - next_index) - 1
                  # creating a read function that has an output argument so data can
                  # be copied directly would be nice
                  # also should move EOFError checking into reader once watchdog
                  # bounds functionality is implemented
                  try:
                      if self._end_sample is None:
                          if read_end > self.bounds[1]:
                              self.bounds = self._Reader.get_bounds(self.chan)
                              read_end = min(read_end, self.bounds[1])
                      else:
                          if read_end > self._end_sample:
                              read_end = self._end_sample
                      if read_start > read_end:
                          raise EOFError
                      # read data
                      data_dict = self.do.read(read_start, read_end, self.chan)
                      # handled all samples through read_end regardless of whether
                      # they were written to the output vector
                      self._read_start_sample = read_end + 1
                      # early escape for no data
                      if not data_dict:
                          if self._gapless:
                              # output empty samples if no data and gapless output
                              stop_index = next_index + read_end + 1 - read_start
                              out[next_index:stop_index] = self._fillvalue
                              next_index = stop_index
                          else:
                              # clear any existing tags
                              self._tag_queue.clear()
                              # add tag at next potential sample to indicate skip
                              self._queue_tags(self._read_start_sample, {})
                          continue
                      # read corresponding metadata
                      if self._DMDReader is not None:
                          meta_dict = self._DMDReader.read(read_start, read_end)
                          for sample, meta in meta_dict.items():
                              # add tags from Digital Metadata
                              # (in addition to default time and rate tags)
                              # eliminate sample_rate_* tags with duplicate info
                              meta.pop("sample_rate_denominator", None)
                              meta.pop("sample_rate_numerator", None)
                              # get center frequencies for rx_freq tag, squeeze()[()]
                              # to get single value if possible else pass as an array
                              cf = meta.pop("center_frequencies", None)
                              if cf is not None:
                                  cf = cf.ravel().squeeze()[()]
                              tags = dict(
                                  rx_freq=cf,
                                  # all other metadata goes in metadata tag
                                  metadata=meta,
                              )
                              self._queue_tags(sample, tags)
                      # add data and tags to output
                      next_continuous_sample = read_start
                      for sample, data in data_dict.items():
                          # detect data skip
                          if sample > next_continuous_sample:
                              if self._gapless:
                                  # advance output by skipped number of samples
                                  nskipped = sample - next_continuous_sample
                                  sample_index = next_index + nskipped
                                  out[next_index:sample_index] = self._fillvalue
                                  next_index = sample_index
                              else:
                                  # emit new time tag at sample to indicate skip
                                  self._queue_tags(sample, {})
                          # output data
                          n = data.shape[0]
                          stop_index = next_index + n
                          end_sample = sample + n
                          out_dest = out[next_index:stop_index]
                          data_arr = data.squeeze()
                          out_dest[:] = data_arr
                          # overwrite missing values with fill values
                          missing_val_idx = self._ismissing(data_arr)
                          out_dest[missing_val_idx] = self._fillvalue
                          # output tags
                          for tag_sample in sorted(self._tag_queue.keys()):
                              if tag_sample < sample:
                                  # drop tags from before current data block
                                  del self._tag_queue[tag_sample]
                                  continue
                              elif tag_sample >= end_sample:
                                  # wait to output tags from after current data block
                                  break
                              offset = (
                                  self.nitems_written(0)  # offset @ start of work
                                  + next_index  # additional offset of data block
                                  + (tag_sample - sample)
                              )
                              tag_dict = self._tag_queue.pop(tag_sample)
                              for name, val in tag_dict.items():
                                  self.add_item_tag(
                                      0, offset, pmt.intern(name), val, self._id
                                  )
                          # advance next output index and continuous sample
                          next_index = stop_index  # <=== next_index += n
                          next_continuous_sample = end_sample
                  except EOFError:
                      if self._repeat:
                          if self._start_sample is None:
                              self._read_start_sample = self.bounds[0]
                          else:
                              self._read_start_sample = self._start_sample
                          self._queue_tags(self._read_start_sample, {})
                          continue
                      else:
                          break
              if next_index == 0:
                  # return WORK_DONE
                  return -1
              return next_index
              '''
    chan: '''misa-l2'''
    comment: |-
      This works

      Basically a Digital
      RF Channel Source
    data_dir: r"E:\pulsar\2022-05-26\usrp-rx0-r_20220526T200000_20220526T210800\rf_data"
    repeat: 'False'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold
      import collections

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Block to perform folding (without importing and using psrdynspec"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Fold',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)
              
              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = collections.deque([])
              
              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              self.data.extend(input_items[0])
              
              if len(self.data) >= self.samp_rate * self.integration_time:
                  times = np.arange(len(self.data)) / self.samp_rate 
                  self.profile = np.nan_to_num(fold.fold_ts(np.array(self.data), times, self.period, self.bins, True))[0]
                  self.data.clear()
                  
              output_items[0][:] = np.array([self.profile])#* output_items[0].shape[0])
              return len(output_items[0])
    comment: |-
      This probably works

      Certainly generates
      pulsar-like profiles
      similar to how I
      generated them in
      shell.
    integration_time: time
    period: period
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold
      import collections

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Block to perform folding (without importing and using psrdynspec"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Fold',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)
              
              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = collections.deque([])
              
              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              self.data.extend(input_items[0])
              
              if len(self.data) >= self.samp_rate * self.integration_time:
                  times = np.arange(len(self.data)) / self.samp_rate 
                  self.profile = np.nan_to_num(fold.fold_ts(np.array(self.data), times, self.period, self.bins, True))[0]
                  self.data.clear()
                  
              output_items[0][:] = np.array([self.profile])#* output_items[0].shape[0])
              return len(output_items[0])
    integration_time: time
    period: period
    samp_rate: 1000000/32
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold
      import collections

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Block to perform folding (without importing and using psrdynspec"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Fold',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)
              
              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = collections.deque([])
              
              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              self.data.extend(input_items[0])
              
              if len(self.data) >= self.samp_rate * self.integration_time:
                  times = np.arange(len(self.data)) / self.samp_rate 
                  self.profile = np.nan_to_num(fold.fold_ts(np.array(self.data), times, self.period, self.bins, True))[0]
                  self.data.clear()
                  
              output_items[0][:] = np.array([self.profile])#* output_items[0].shape[0])
              return len(output_items[0])
    integration_time: time
    period: 32000/samp_rate
    samp_rate: samp_rate/32
  states: {state: disabled}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold
      import collections

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Block to perform folding (without importing and using psrdynspec"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Fold',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)
              
              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = collections.deque([])
              
              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              self.data.extend(input_items[0])
              
              if len(self.data) >= self.samp_rate * self.integration_time:
                  times = np.arange(len(self.data)) / self.samp_rate 
                  self.profile = np.nan_to_num(fold.fold_ts(np.array(self.data), times, self.period, self.bins, True))[0]
                  self.data.clear()
                  
              output_items[0][:] = np.array([self.profile]* output_items[0].shape[0])
              return len(output_items[0])
    integration_time: time
    period: 32000/samp_rate
    samp_rate: samp_rate/32
  states: {state: disabled}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold


      class fold_blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Block to perform folding (without importing and using psrdynspec"""

          def __init__(self, period=.0335, samp_rate=1000000/32, integration_time=10.):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Fold',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)
              
              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)
              
              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              self.data = np.append(self.data, input_items[0])
              
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate 
                  self.profile = np.nan_to_num(fold.fold_ts(self.data, times, self.period, self.bins, True))[0]
                  self.data = np.array([], dtype=np.float32)
                  
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    comment: |-
      This probably works

      Certainly generates
      pulsar-like profiles
      similar to how I
      generated them in
      shell.
    integration_time: time
    period: 32000/samp_rate
    samp_rate: 1000000/32
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import scipy
      from scipy import stats
      import collections


      class filter_outlier_blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=1000000/32, time=30, deviations=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations
              
              self.buffer = collections.deque([])
              self.data = np.array([], dtype=np.float32)
              self.median = 0.
              self.mad = 0.

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              nsamps = self.samp_rate * self.time
              self.buffer.extend(input_items[0])
              while len(self.buffer) > nsamps:
                  self.buffer.popleft()
                  
              self.data = input_items[0].copy()
              
              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)
              
              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    comment: |-
      This certainly works.

      Filters out outliers.
    deviations: '10'
    samp_rate: samp_rate
    time: '10'
  states: {state: disabled}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import scipy
      from scipy import stats
      import collections


      class filter_outlier_blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=1000000/32, time=30, deviations=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations
              
              self.buffer = collections.deque([])
              self.data = np.array([], dtype=np.float32)
              self.median = 0.
              self.mad = 0.

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              nsamps = self.samp_rate * self.time
              self.buffer.extend(input_items[0])
              while len(self.buffer) > nsamps:
                  self.buffer.popleft()
                  
              self.data = input_items[0].copy()
              
              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)
              
              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    comment: |-
      This certainly works.

      Filters out outliers.
    deviations: dev
    samp_rate: samp_rate
    time: filt_time
  states: {}
- name: epy_block_2_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import scipy
      from scipy import stats


      class filter_outlier_blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=1000000/32, time=30, deviations=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations
              
              self.buffer = np.array([], dtype=np.float32)
              self.data = np.array([], dtype=np.float32)
              self.median = 0.
              self.mad = 0.

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              nsamps = self.samp_rate * self.time
              if self.buffer.size < nsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > nsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - nsamps))
                  
              self.data = input_items[0].copy()
              
              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)
              
              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    comment: |-
      This certainly works.

      Filters out outliers.
    deviations: dev
    samp_rate: samp_rate
    time: filt_time
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import mitarspysigproc.filtertools as filtert
  states: {}
- name: note_0
  id: note
  parameters:
    note: remember to mod DRF
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Next step now is to fine-tune variables to see pulsar

      Note that I sped things up be speeding up rate into which
      samples were pass and by changing buffers from arrays
      to deques.

      Tests to run:
      	- fine tune deviations filtering
      	- fine tune integration time
      	- fine tune median calc time

      Do these tests with same data set (save a few minutes of 
      DRF data and then have it repeat over and over to have controlled
      data--make sure to pick a good channel and good time).
    note: okay, so blocks work
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: channel
    decim: '32'
    taps: filtert.kaiser_coeffs(32)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (5, 0)
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (2,0)
    label1: Unfiltered
    label2: Filtered
    nconnections: '2'
    vlen: '1024'
    x_axis_label: '"Phase"'
    x_start: '0'
    x_step: 1/1024
    y_axis_label: '"Power"'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    label1: Short
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_1_0
  id: qtgui_vector_sink_f
  parameters:
    label1: Long
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_1_0_0
  id: qtgui_vector_sink_f
  parameters:
    label1: Old
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', epy_block_1, '0']
- [blocks_add_xx_0, '0', epy_block_2_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', epy_block_1_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', epy_block_1_0_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', epy_block_1_1, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_tags_strobe_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', pfb_decimator_ccf_0, '0']
- [blocks_throttle_0_0, '0', epy_block_2, '0']
- [blocks_throttle_0_0, '0', epy_block_2_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '1']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_1_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_1_0, '0', qtgui_vector_sink_f_0, '1']
- [epy_block_1_0_0, '0', qtgui_vector_sink_f_1, '0']
- [epy_block_1_0_0_0, '0', qtgui_vector_sink_f_1_0, '0']
- [epy_block_1_1, '0', qtgui_vector_sink_f_1_0_0, '0']
- [epy_block_2, '0', qtgui_time_sink_x_0, '0']
- [epy_block_2_0, '0', epy_block_1_0, '0']
- [epy_block_2_0_0, '0', qtgui_time_sink_x_0, '1']
- [pfb_decimator_ccf_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
