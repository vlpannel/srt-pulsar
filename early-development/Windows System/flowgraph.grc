options:
  parameters:
    generate_options: qt_gui
    id: flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chan
  id: variable
  parameters:
    value: '"misa-l2"'
  states: {}
- name: drf_data
  id: variable
  parameters:
    value: r"E:\pulsar\2022-05-26\usrp-rx0-r_20220526T200000_20220526T210800\rf_data"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_10
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_11
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_12
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_13
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_14
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_15
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_16
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_17
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_18
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_19
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_20
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_21
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_22
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_23
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_24
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_25
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_26
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_27
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_28
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_29
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_4
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_5
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_6
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_7
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_8
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_9
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch0
    type: complex
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch1
    type: complex
  states: {}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch20
    type: complex
  states: {}
- name: blocks_file_sink_1_10
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch27
    type: complex
  states: {}
- name: blocks_file_sink_1_10_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch29
    type: complex
  states: {}
- name: blocks_file_sink_1_10_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch28
    type: complex
  states: {}
- name: blocks_file_sink_1_10_2
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch30
    type: complex
  states: {}
- name: blocks_file_sink_1_10_2_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch31
    type: complex
  states: {}
- name: blocks_file_sink_1_11
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch26
    type: complex
  states: {}
- name: blocks_file_sink_1_12
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch25
    type: complex
  states: {}
- name: blocks_file_sink_1_13
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch24
    type: complex
  states: {}
- name: blocks_file_sink_1_14
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch23
    type: complex
  states: {}
- name: blocks_file_sink_1_15
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch22
    type: complex
  states: {}
- name: blocks_file_sink_1_16
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch4
    type: complex
  states: {}
- name: blocks_file_sink_1_17
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch3
    type: complex
  states: {}
- name: blocks_file_sink_1_18
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch2
    type: complex
  states: {}
- name: blocks_file_sink_1_19
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch14
    type: complex
  states: {}
- name: blocks_file_sink_1_2
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch19
    type: complex
  states: {}
- name: blocks_file_sink_1_20
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch21
    type: complex
  states: {}
- name: blocks_file_sink_1_21
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch13
    type: complex
  states: {}
- name: blocks_file_sink_1_22
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch12
    type: complex
  states: {}
- name: blocks_file_sink_1_23
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch11
    type: complex
  states: {}
- name: blocks_file_sink_1_24
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch10
    type: complex
  states: {}
- name: blocks_file_sink_1_25
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch9
    type: complex
  states: {}
- name: blocks_file_sink_1_26
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch8
    type: complex
  states: {}
- name: blocks_file_sink_1_3
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch18
    type: complex
  states: {}
- name: blocks_file_sink_1_4
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch17
    type: complex
  states: {}
- name: blocks_file_sink_1_5
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch16
    type: complex
  states: {}
- name: blocks_file_sink_1_6
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch15
    type: complex
  states: {}
- name: blocks_file_sink_1_7
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch7
    type: complex
  states: {}
- name: blocks_file_sink_1_8
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch6
    type: complex
  states: {}
- name: blocks_file_sink_1_9
  id: blocks_file_sink
  parameters:
    file: C:\Users\vlpannel\Desktop\newpfbdata\ch5
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from __future__ import absolute_import, division, print_function

      import os
      import traceback

      import gnuradio.blocks
      import h5py
      import pmt
      import six


      import numpy as np
      from gnuradio import gr
      import digital_rf as drf
      from digital_rf import DigitalRFReader, util


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Modified version of DRF Source"""

          def __init__(self, data_dir=r'E:\pulsar\2022-05-26\usrp-rx0-r_20220526T200000_20220526T210800\rf_data', chan='misa-l2', repeat=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Modified DRF Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              self.data_dir = data_dir
              self.chan = chan
              self.repeat = repeat    # repeat flag: currently nonfunctional, but may be useful later
              
              self.do = drf.DigitalRFReader(self.data_dir)
              self.bounds = self.do.get_bounds(self.chan)
              self.prop = self.do.get_properties(self.chan)
              
              self.index = self.bounds[0]# + (16 * 1000000)     # start at first sample
              self.result = 0
              
          def work(self, input_items, output_items):
              out = output_items[0]
              nsamples = len(out)
              data = self.do.read_vector(self.index, nsamples, self.chan)
              self.index += nsamples
              
              output_items[0][:] = data
              
              return len(output_items[0])
          '''
          def work(self, input_items, output_items):
              #ADDED CONTENT
              self._start_sample = util.parse_identifier_to_sample(
                  None, self.prop["samples_per_second"], self.bounds[0]
              )
              self._end_sample = util.parse_identifier_to_sample(
                  None, self.prop["samples_per_second"], self.bounds[0]
              )
              self._gapless = True
              if self._start_sample is None:
                  self._read_start_sample = self.bounds[0]
              else:
                  self._read_start_sample = self._start_sample
              
              out = output_items[0]
              nsamples = len(out)
              next_index = 0
              # repeat reading until we succeed or return
              while next_index < nsamples:
                  read_start = self._read_start_sample
                  # read_end is inclusive, hence the -1
                  read_end = self._read_start_sample + (nsamples - next_index) - 1
                  # creating a read function that has an output argument so data can
                  # be copied directly would be nice
                  # also should move EOFError checking into reader once watchdog
                  # bounds functionality is implemented
                  try:
                      if self._end_sample is None:
                          if read_end > self.bounds[1]:
                              self.bounds = self._Reader.get_bounds(self.chan)
                              read_end = min(read_end, self.bounds[1])
                      else:
                          if read_end > self._end_sample:
                              read_end = self._end_sample
                      if read_start > read_end:
                          raise EOFError
                      # read data
                      data_dict = self.do.read(read_start, read_end, self.chan)
                      # handled all samples through read_end regardless of whether
                      # they were written to the output vector
                      self._read_start_sample = read_end + 1
                      # early escape for no data
                      if not data_dict:
                          if self._gapless:
                              # output empty samples if no data and gapless output
                              stop_index = next_index + read_end + 1 - read_start
                              out[next_index:stop_index] = self._fillvalue
                              next_index = stop_index
                          else:
                              # clear any existing tags
                              self._tag_queue.clear()
                              # add tag at next potential sample to indicate skip
                              self._queue_tags(self._read_start_sample, {})
                          continue
                      # read corresponding metadata
                      if self._DMDReader is not None:
                          meta_dict = self._DMDReader.read(read_start, read_end)
                          for sample, meta in meta_dict.items():
                              # add tags from Digital Metadata
                              # (in addition to default time and rate tags)
                              # eliminate sample_rate_* tags with duplicate info
                              meta.pop("sample_rate_denominator", None)
                              meta.pop("sample_rate_numerator", None)
                              # get center frequencies for rx_freq tag, squeeze()[()]
                              # to get single value if possible else pass as an array
                              cf = meta.pop("center_frequencies", None)
                              if cf is not None:
                                  cf = cf.ravel().squeeze()[()]
                              tags = dict(
                                  rx_freq=cf,
                                  # all other metadata goes in metadata tag
                                  metadata=meta,
                              )
                              self._queue_tags(sample, tags)
                      # add data and tags to output
                      next_continuous_sample = read_start
                      for sample, data in data_dict.items():
                          # detect data skip
                          if sample > next_continuous_sample:
                              if self._gapless:
                                  # advance output by skipped number of samples
                                  nskipped = sample - next_continuous_sample
                                  sample_index = next_index + nskipped
                                  out[next_index:sample_index] = self._fillvalue
                                  next_index = sample_index
                              else:
                                  # emit new time tag at sample to indicate skip
                                  self._queue_tags(sample, {})
                          # output data
                          n = data.shape[0]
                          stop_index = next_index + n
                          end_sample = sample + n
                          out_dest = out[next_index:stop_index]
                          data_arr = data.squeeze()
                          out_dest[:] = data_arr
                          # overwrite missing values with fill values
                          missing_val_idx = self._ismissing(data_arr)
                          out_dest[missing_val_idx] = self._fillvalue
                          # output tags
                          for tag_sample in sorted(self._tag_queue.keys()):
                              if tag_sample < sample:
                                  # drop tags from before current data block
                                  del self._tag_queue[tag_sample]
                                  continue
                              elif tag_sample >= end_sample:
                                  # wait to output tags from after current data block
                                  break
                              offset = (
                                  self.nitems_written(0)  # offset @ start of work
                                  + next_index  # additional offset of data block
                                  + (tag_sample - sample)
                              )
                              tag_dict = self._tag_queue.pop(tag_sample)
                              for name, val in tag_dict.items():
                                  self.add_item_tag(
                                      0, offset, pmt.intern(name), val, self._id
                                  )
                          # advance next output index and continuous sample
                          next_index = stop_index  # <=== next_index += n
                          next_continuous_sample = end_sample
                  except EOFError:
                      if self._repeat:
                          if self._start_sample is None:
                              self._read_start_sample = self.bounds[0]
                          else:
                              self._read_start_sample = self._start_sample
                          self._queue_tags(self._read_start_sample, {})
                          continue
                      else:
                          break
              if next_index == 0:
                  # return WORK_DONE
                  return -1
              return next_index
              '''
    chan: '''misa-l2'''
    data_dir: r"E:\pulsar\2022-05-26\usrp-rx0-r_20220526T200000_20220526T210800\rf_data"
    repeat: 'False'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    Nbins: ''
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold as fld


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, nsamp=1000000, samp_rate=1000000., per=0.0335, Nbins=1024):  # only default arguments here     (change nsamp)
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Folding',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32, Nbins)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.nsamp = nsamp
              self.samp_rate = samp_rate
              self.per = per
              self.Nbins = Nbins
              
              self.time0 = 0.
              

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    nsamp: ''
    per: ''
    samp_rate: ''
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import mitarspysigproc.filtertools as filtertools
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    nchans: '32'
    osr: '1.0'
    taps: filtertools.kaiser_coeffs(32)
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_complex_to_mag_squared_1, '0']
- [pfb_channelizer_ccf_0, '0', blocks_file_sink_1, '0']
- [pfb_channelizer_ccf_0, '0', qtgui_time_sink_x_1, '0']
- [pfb_channelizer_ccf_0, '1', blocks_complex_to_mag_squared_1_28, '0']
- [pfb_channelizer_ccf_0, '1', blocks_file_sink_1_0, '0']
- [pfb_channelizer_ccf_0, '10', blocks_complex_to_mag_squared_1_20, '0']
- [pfb_channelizer_ccf_0, '10', blocks_file_sink_1_24, '0']
- [pfb_channelizer_ccf_0, '11', blocks_complex_to_mag_squared_1_19, '0']
- [pfb_channelizer_ccf_0, '11', blocks_file_sink_1_23, '0']
- [pfb_channelizer_ccf_0, '12', blocks_complex_to_mag_squared_1_18, '0']
- [pfb_channelizer_ccf_0, '12', blocks_file_sink_1_22, '0']
- [pfb_channelizer_ccf_0, '13', blocks_complex_to_mag_squared_1_17, '0']
- [pfb_channelizer_ccf_0, '13', blocks_file_sink_1_21, '0']
- [pfb_channelizer_ccf_0, '14', blocks_complex_to_mag_squared_1_16, '0']
- [pfb_channelizer_ccf_0, '14', blocks_file_sink_1_19, '0']
- [pfb_channelizer_ccf_0, '15', blocks_complex_to_mag_squared_1_15, '0']
- [pfb_channelizer_ccf_0, '15', blocks_file_sink_1_6, '0']
- [pfb_channelizer_ccf_0, '16', blocks_complex_to_mag_squared_1_14, '0']
- [pfb_channelizer_ccf_0, '16', blocks_file_sink_1_5, '0']
- [pfb_channelizer_ccf_0, '17', blocks_complex_to_mag_squared_1_13, '0']
- [pfb_channelizer_ccf_0, '17', blocks_file_sink_1_4, '0']
- [pfb_channelizer_ccf_0, '18', blocks_complex_to_mag_squared_1_12, '0']
- [pfb_channelizer_ccf_0, '18', blocks_file_sink_1_3, '0']
- [pfb_channelizer_ccf_0, '19', blocks_complex_to_mag_squared_1_11, '0']
- [pfb_channelizer_ccf_0, '19', blocks_file_sink_1_2, '0']
- [pfb_channelizer_ccf_0, '2', blocks_complex_to_mag_squared_1_29, '0']
- [pfb_channelizer_ccf_0, '2', blocks_file_sink_1_18, '0']
- [pfb_channelizer_ccf_0, '20', blocks_complex_to_mag_squared_1_10, '0']
- [pfb_channelizer_ccf_0, '20', blocks_file_sink_1_1, '0']
- [pfb_channelizer_ccf_0, '21', blocks_complex_to_mag_squared_1_9, '0']
- [pfb_channelizer_ccf_0, '21', blocks_file_sink_1_20, '0']
- [pfb_channelizer_ccf_0, '22', blocks_complex_to_mag_squared_1_8, '0']
- [pfb_channelizer_ccf_0, '22', blocks_file_sink_1_15, '0']
- [pfb_channelizer_ccf_0, '23', blocks_complex_to_mag_squared_1_7, '0']
- [pfb_channelizer_ccf_0, '23', blocks_file_sink_1_14, '0']
- [pfb_channelizer_ccf_0, '24', blocks_complex_to_mag_squared_1_6, '0']
- [pfb_channelizer_ccf_0, '24', blocks_file_sink_1_13, '0']
- [pfb_channelizer_ccf_0, '25', blocks_complex_to_mag_squared_1_5, '0']
- [pfb_channelizer_ccf_0, '25', blocks_file_sink_1_12, '0']
- [pfb_channelizer_ccf_0, '26', blocks_complex_to_mag_squared_1_4, '0']
- [pfb_channelizer_ccf_0, '26', blocks_file_sink_1_11, '0']
- [pfb_channelizer_ccf_0, '27', blocks_complex_to_mag_squared_1_3, '0']
- [pfb_channelizer_ccf_0, '27', blocks_file_sink_1_10, '0']
- [pfb_channelizer_ccf_0, '28', blocks_complex_to_mag_squared_1_2, '0']
- [pfb_channelizer_ccf_0, '28', blocks_file_sink_1_10_1, '0']
- [pfb_channelizer_ccf_0, '29', blocks_complex_to_mag_squared_1_1, '0']
- [pfb_channelizer_ccf_0, '29', blocks_file_sink_1_10_0, '0']
- [pfb_channelizer_ccf_0, '3', blocks_complex_to_mag_squared_1_27, '0']
- [pfb_channelizer_ccf_0, '3', blocks_file_sink_1_17, '0']
- [pfb_channelizer_ccf_0, '30', blocks_complex_to_mag_squared_1_0, '0']
- [pfb_channelizer_ccf_0, '30', blocks_file_sink_1_10_2, '0']
- [pfb_channelizer_ccf_0, '31', blocks_file_sink_1_10_2_0, '0']
- [pfb_channelizer_ccf_0, '4', blocks_complex_to_mag_squared_1_26, '0']
- [pfb_channelizer_ccf_0, '4', blocks_file_sink_1_16, '0']
- [pfb_channelizer_ccf_0, '5', blocks_complex_to_mag_squared_1_25, '0']
- [pfb_channelizer_ccf_0, '5', blocks_file_sink_1_9, '0']
- [pfb_channelizer_ccf_0, '6', blocks_complex_to_mag_squared_1_24, '0']
- [pfb_channelizer_ccf_0, '6', blocks_file_sink_1_8, '0']
- [pfb_channelizer_ccf_0, '7', blocks_complex_to_mag_squared_1_23, '0']
- [pfb_channelizer_ccf_0, '7', blocks_file_sink_1_7, '0']
- [pfb_channelizer_ccf_0, '8', blocks_complex_to_mag_squared_1_22, '0']
- [pfb_channelizer_ccf_0, '8', blocks_file_sink_1_26, '0']
- [pfb_channelizer_ccf_0, '9', blocks_complex_to_mag_squared_1_21, '0']
- [pfb_channelizer_ccf_0, '9', blocks_file_sink_1_25, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
