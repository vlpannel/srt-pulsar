options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: chan
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: C:\\Users\\vlpannel\\Desktop\\out_test
    uuid: ''
    vlen: '1'
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: chan
    end0: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'False'
    top_level_dir: C:\\Users\\vlpannel\\Desktop\\out_test
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      DRF works here!
      However, it takes
      a really long time
      if a lot of data is
      sampled (make 
      sure to use 
      indices for more than
      5 sec of data). Also,
      repeat playback
      also works. DRF can
      save and read
      data samples in
      cf32.
    note: drf
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
