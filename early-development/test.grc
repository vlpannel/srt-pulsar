options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: pulsar_dedisp_incoherent_0
  id: pulsar_dedisp_incoherent
  parameters:
    bandwidth: '1'
    center_freq: '440'
    center_freq_0: '440'
    dm: '56.77118'
    num_channels: '32'
    samp_rate: '1000000'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', pulsar_dedisp_incoherent_0, '0']
- [blocks_null_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_null_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [pulsar_dedisp_incoherent_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
