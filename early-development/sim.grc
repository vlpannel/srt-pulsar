options:
  parameters:
    generate_options: qt_gui
    id: simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.repeat(np.arange(0, .5, .0001), pulspy.pulsing_repeats(samp_rate, np.arange(0, .5, .0001)))
  states: {}
- name: channels_channel_model2_0
  id: channels_channel_model2
  parameters:
    epsilon: '1.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_dynamic_channel_model_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: 0.0,0.1,1.3
    fD: '2.0'
    mags: 1,0.99,0.97
    noise_amp: '1.0'
    ntaps: '8'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Pulse block - Only allows signal to pass once a certain number of samples are passed inl"""

          def __init__(self, samp_rate=1000000, period=.033):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Pulse',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samp_rate = samp_rate
              self.period = period
              self.counter = 0
              self.reset = self.period + 10

          def work(self, input_items, output_items):
              """Change amplitude of signal based on how many points passed through."""
              
              if self.counter > self.reset:
                  self.counter = 0
              
              if self.counter > self.period:
                  output_items[0][:] = input_items[0][:]
              else:
                  output_items[0][:] = 0
              
              self.counter += len(output_items[0])
              
              return len(output_items[0])
    period: '1'
    samp_rate: '32000'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Pulsar Frequency',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        \n        self.strobePortName = 'Strobe'\n        self.message_port_register_in(pmt.intern(self.strobePortName))\n        self.set_msg_handler(pmt.intern(self.strobePortName), self.handle_msg)\n        self.pulse = False\n        \n        self.outPortName = 'freq'\n        self.\n    \n    def handle_msg(self, msg):\n        self.selector = pmt.to_bool(msg)\n    \n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if self.selector:\n            \n        return len(output_items[0])\n    "
    example_param: '1.0'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This theoretical pulsar
      has a period of 0.033
      and a dispersion measure
      of 0.0127 (arxiv.org/abs/220
      7.04267) and only one
      pulse per period.
    note: pulsar sim
  states: {}
- name: pulspy
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      import numpy as np

      def pulsing_repeats(sr, ran):
          '''
          Parameters
          ----------

          sr : float
              Sample rate (determines frequencies that pulse goes over)

          ran : array-like, numpy array
              Range of values where frequency varies


          Returns
          -------

          repeats : array-like
              Number of samples at each frequency (before pulse moves to next frequency)
          '''

          # based on dispersion measure equation

          dm = .0127 # dispersion measure [pc*cm^-3]: arxiv.org/abs/2207.04267
          kdm = 4.149e18 # dispersion constant [Hz^2*pc^-1*cm^3*ms] (converted from units of GHz^2 to Hz^2)

          # nu2^-2 - nu1^-2 [Hz^-2]
          freq_diff = np.array([(sr * ran[i])**(-2) - (sr * ran[i + 1])**(-2) for i in range(ran.size - 1)])
          np.append(freq_diff, 0)
          assert freq_diff.size == ran.size

          # change in time between two frequencies (∆t) [ms]
          t = dm * kdm * freq_diff

          # convert time to number of samples
          repeats = np.array(t * samp_rate / 1000, dtype='int')
          repeats[0] = repeats[0] * -1  # because conversion from 'inf' yields large negative int
          return repeats
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (1, 0, 1, 2)
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0,0)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0, 1)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', channels_channel_model2_0, '2']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', channels_channel_model2_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_1, '0', qtgui_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', channels_channel_model2_0, '1']
- [channels_channel_model2_0, '0', blocks_throttle_1, '0']
- [channels_channel_model2_0, '0', qtgui_sink_x_0, '0']
- [epy_block_0, '0', qtgui_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
