options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: store_channels
    output_language: python
    title: Channelize DRF Data
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: subchannels
  id: variable
  parameters:
    comment: |-
      The number of
      subchannels a
      channel being
      read has.
    value: '2'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_1
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: subchannels
    type: short
  states: {}
- name: chan_name
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      """
      This code generates the names of the files that store each channel output.
      """

      def name(num):
          return '/Users/vivelpanel/Desktop/SRT UROP 2022/Spectrogram/channels/created_channel_' + str(num)

      # will finish below code later--for now it is much more complicated
      # than necessary, so I use the simpler scheme above
      """
      class ChannelFile:
          filepath = '/Users/vivelpanel/Desktop/SRT UROP 2022/Spectrogram/channels/'
          basename = 'created_channel_'
          index = 0

          def __init__(self, num=index):
              self.filename = filepath + basename + str(num)
              if num == index:
                  index += 1

          def get_name(self, num):
              if 
              return self.filename
      """
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    channel1: ch1
    channel2: ch2
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: s16
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '3'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: '1653595200000000'
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: /Users/vivelpanel/Desktop/SRT UROP 2022/Spectrogram/drf_out
    uuid: ''
    vlen: '1'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: misa-l2
    end0: '1653602399999999'
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: '1653595200000000'
    throttle: 'False'
    top_level_dir: '"/Volumes/NO Name/pulsar/2022-05-26/rf_data"'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Stored DRF file is empty... except
      for metadata
    note: Stored DRF file is empty
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: '3'
    osr: '1.0'
    taps: '[]'
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', gr_digital_rf_digital_rf_sink_0, '2']
- [blocks_complex_to_interleaved_short_0_1, '0', gr_digital_rf_digital_rf_sink_0, '1']
- [blocks_interleaved_short_to_complex_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_throttle_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_vector_to_streams_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_complex_to_interleaved_short_0_1, '0']
- [pfb_channelizer_ccf_0, '2', blocks_complex_to_interleaved_short_0_0, '0']

metadata:
  file_format: 1
