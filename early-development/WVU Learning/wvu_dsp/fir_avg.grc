options:
  parameters:
    generate_options: hb
    id: fir_movingaverage
    output_language: python
    title: 'FIR (Finite Impulse Response): Moving Average'
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: '3'
    type: complex
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: '7'
    type: complex
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: '6'
    type: complex
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: '4'
    type: complex
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: '5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/8
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: unfiltered
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: filtered
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: sine_wave
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: noise
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_delay_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_1, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_3, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_4, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_5, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_6, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_1, '2']
- [blocks_delay_0_1, '0', blocks_add_xx_1, '3']
- [blocks_delay_0_3, '0', blocks_add_xx_1, '7']
- [blocks_delay_0_4, '0', blocks_add_xx_1, '6']
- [blocks_delay_0_5, '0', blocks_add_xx_1, '4']
- [blocks_delay_0_6, '0', blocks_add_xx_1, '5']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0_0, '0']
- [pad_source_0, '0', blocks_add_xx_0, '0']
- [pad_source_0_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
