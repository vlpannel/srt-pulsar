options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: am_freq
  id: variable
  parameters:
    value: 590e3
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    comment: WMBR is 88.1 MHz
    value: 88.1e6
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 100e3
    step: '1'
    stop: 500e6
    value: 100e6
  states: {state: disabled}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int(samp_rate/(2*channel_width))
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: out_rate/(2*math.pi*channel_width)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: am_freq + channel_width / 2
    low_cutoff_freq: am_freq - channel_width / 2
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: channel_width
    decim: int(samp_rate/(2*channel_width))
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 18e3
    decim: '4'
    gain: '1'
    samp_rate: out_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: note_0
  id: note
  parameters:
    comment: This is an FM Radio demodulator.
    note: This works!
  states: {}
- name: note_1
  id: note
  parameters:
    comment: This is an AM radio demodulator.
    note: doesn't work (yet?)
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"RTL-SDR Signal (and DSP)"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/decimation)
    interp: int(out_rate)
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/decimation)
    interp: int(out_rate)
    type: ccc
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '45'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_float_0, '0', audio_sink_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_1, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_0, '0']
- [rtlsdr_source_0, '0', band_pass_filter_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
