options:
  parameters:
    author: Viveca Pannell
    generate_options: hb
    id: pulsar_hier_32channel
    output_language: python
    title: pulsar_hier_32channels
  states: {}

blocks:
- name: bandwidth
  id: parameter
  parameters:
    label: Bandwidth (MHz)
    type: eng_float
    value: '1'
  states: {}
- name: baseline_time
  id: parameter
  parameters:
    label: FIR filter time
    type: eng_float
    value: '30'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '32'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_10
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_11
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_12
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_13
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_14
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_15
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_16
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_17
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_18
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_19
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_20
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_21
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_22
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_23
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_24
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_25
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_26
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_27
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_28
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_29
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_30
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_4
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_5
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_6
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_7
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_8
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_9
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 0, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 1, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 2, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_10
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 11, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_11
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 12, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_12
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 13, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_13
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 14, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 15, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 17, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_1
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 18, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_10
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 27, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_11
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 28, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_12
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 29, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_13
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 30, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_14
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 31, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_2
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 19, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_3
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 20, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_4
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 21, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_5
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 22, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_6
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 23, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_7
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 24, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_8
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 25, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_9
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 26, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_15
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 16, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 3, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 4, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 5, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 6, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 7, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_7
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 8, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_8
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 9, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_9
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, 32, 10, dm, samp_rate/32)
    type: float
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center frequency (MHz)
    type: eng_float
    value: '440'
  states: {}
- name: deviations
  id: parameter
  parameters:
    label: Deviations
    type: eng_float
    value: '10'
  states: {}
- name: dm
  id: parameter
  parameters:
    label: Dispersion measure
    type: eng_float
    value: '56.77118'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_10
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_11
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_12
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_13
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_10
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_11
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_12
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_13
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_14
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_6
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_7
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_8
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_14_9
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_15
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_6
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_7
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_8
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_0_0_9
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=0.0333924123 , samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              Always outputs the last calculated phase vs. power profile.

              After calculating, immediately begins collecting data for a new calculation.
              
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enough data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: integration_time
    period: period
    samp_rate: samp_rate / 32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import mitarspysigproc.filtertools as filtertools
  states: {}
- name: inco_dedisp
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\ndef dedisperse(center_freq, bandwidth, num_channels, channel, dm, samp_rate):\n    '''\n    Delay channel be specified amount given frequencies and dispersion measure. Assumes standard channel mapping and even number of channels. Aligns all channels with lowest channel (for delay purposes).\n\n    Parameters\n    ----------\n\n    center_freq : float\n        Center frequency in MHz\n\n    bandwidth : float\n        Total bandwidth of signal reception in MHz\n\n    num_channels : int\n        Number of channels into which bandwidth is divided (equally)\n\n    channel : int\n        Which channel is being dedispersed (0 is at center frequency)\n\n    dm : float\n        Dispersion measure of pulsar\n\n    samp_rate : float\n        Sample rate of incoming samples (samples per second)\n    '''\n\n    kdm = 4.149 * 1000    # dispersion measure constant (converted from GHz^2 to MHz^2 and ms to s)\n\n    # find frequencies of lowest channel and current channel\n    channel_width = bandwidth / num_channels\n    v2 = center_freq - (bandwidth/2)     # lowest frequency\n    if channel <= num_channels/2:       # current channel\n        v1 = center_freq + (channel)*channel_width\n    else:\n        v1 = center_freq - (num_channels - channel)*channel_width\n\n    # find amount of dispersion\n    time_delta = kdm * dm * ((1/(v2**2)) - (1/(v1**2)))\n    return int(time_delta * samp_rate)\n    \n"
  states: {}
- name: integration_time
  id: parameter
  parameters:
    label: Integration time
    type: eng_float
    value: '120'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: '1024'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: period
  id: parameter
  parameters:
    label: Period
    type: eng_float
    value: '.03339'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: '32'
    osr: '1.0'
    taps: filtertools.kaiser_coeffs(32)
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '1000000'
  states: {}

connections:
- [blocks_add_xx_1, '0', epy_block_1_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', epy_block_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', epy_block_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_1, '0', epy_block_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_0_10, '0', epy_block_0_0_10, '0']
- [blocks_complex_to_mag_squared_0_0_11, '0', epy_block_0_0_11, '0']
- [blocks_complex_to_mag_squared_0_0_12, '0', epy_block_0_0_12, '0']
- [blocks_complex_to_mag_squared_0_0_13, '0', epy_block_0_0_13, '0']
- [blocks_complex_to_mag_squared_0_0_14, '0', epy_block_0_0_14, '0']
- [blocks_complex_to_mag_squared_0_0_15, '0', epy_block_0_0_15, '0']
- [blocks_complex_to_mag_squared_0_0_16, '0', epy_block_0_0_14_0, '0']
- [blocks_complex_to_mag_squared_0_0_17, '0', epy_block_0_0_14_1, '0']
- [blocks_complex_to_mag_squared_0_0_18, '0', epy_block_0_0_14_2, '0']
- [blocks_complex_to_mag_squared_0_0_19, '0', epy_block_0_0_14_3, '0']
- [blocks_complex_to_mag_squared_0_0_2, '0', epy_block_0_0_2, '0']
- [blocks_complex_to_mag_squared_0_0_20, '0', epy_block_0_0_14_4, '0']
- [blocks_complex_to_mag_squared_0_0_21, '0', epy_block_0_0_14_5, '0']
- [blocks_complex_to_mag_squared_0_0_22, '0', epy_block_0_0_14_6, '0']
- [blocks_complex_to_mag_squared_0_0_23, '0', epy_block_0_0_14_7, '0']
- [blocks_complex_to_mag_squared_0_0_24, '0', epy_block_0_0_14_8, '0']
- [blocks_complex_to_mag_squared_0_0_25, '0', epy_block_0_0_14_9, '0']
- [blocks_complex_to_mag_squared_0_0_26, '0', epy_block_0_0_14_10, '0']
- [blocks_complex_to_mag_squared_0_0_27, '0', epy_block_0_0_14_11, '0']
- [blocks_complex_to_mag_squared_0_0_28, '0', epy_block_0_0_14_12, '0']
- [blocks_complex_to_mag_squared_0_0_29, '0', epy_block_0_0_14_13, '0']
- [blocks_complex_to_mag_squared_0_0_3, '0', epy_block_0_0_3, '0']
- [blocks_complex_to_mag_squared_0_0_30, '0', epy_block_0_0_14_14, '0']
- [blocks_complex_to_mag_squared_0_0_4, '0', epy_block_0_0_4, '0']
- [blocks_complex_to_mag_squared_0_0_5, '0', epy_block_0_0_5, '0']
- [blocks_complex_to_mag_squared_0_0_6, '0', epy_block_0_0_6, '0']
- [blocks_complex_to_mag_squared_0_0_7, '0', epy_block_0_0_7, '0']
- [blocks_complex_to_mag_squared_0_0_8, '0', epy_block_0_0_8, '0']
- [blocks_complex_to_mag_squared_0_0_9, '0', epy_block_0_0_9, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_1, '1']
- [blocks_delay_0_1, '0', blocks_add_xx_1, '2']
- [blocks_delay_0_10, '0', blocks_add_xx_1, '11']
- [blocks_delay_0_11, '0', blocks_add_xx_1, '12']
- [blocks_delay_0_12, '0', blocks_add_xx_1, '13']
- [blocks_delay_0_13, '0', blocks_add_xx_1, '14']
- [blocks_delay_0_14, '0', blocks_add_xx_1, '15']
- [blocks_delay_0_14_0, '0', blocks_add_xx_1, '17']
- [blocks_delay_0_14_1, '0', blocks_add_xx_1, '18']
- [blocks_delay_0_14_10, '0', blocks_add_xx_1, '27']
- [blocks_delay_0_14_11, '0', blocks_add_xx_1, '28']
- [blocks_delay_0_14_12, '0', blocks_add_xx_1, '29']
- [blocks_delay_0_14_13, '0', blocks_add_xx_1, '30']
- [blocks_delay_0_14_14, '0', blocks_add_xx_1, '31']
- [blocks_delay_0_14_2, '0', blocks_add_xx_1, '19']
- [blocks_delay_0_14_3, '0', blocks_add_xx_1, '20']
- [blocks_delay_0_14_4, '0', blocks_add_xx_1, '21']
- [blocks_delay_0_14_5, '0', blocks_add_xx_1, '22']
- [blocks_delay_0_14_6, '0', blocks_add_xx_1, '23']
- [blocks_delay_0_14_7, '0', blocks_add_xx_1, '24']
- [blocks_delay_0_14_8, '0', blocks_add_xx_1, '25']
- [blocks_delay_0_14_9, '0', blocks_add_xx_1, '26']
- [blocks_delay_0_15, '0', blocks_add_xx_1, '16']
- [blocks_delay_0_2, '0', blocks_add_xx_1, '3']
- [blocks_delay_0_3, '0', blocks_add_xx_1, '4']
- [blocks_delay_0_4, '0', blocks_add_xx_1, '5']
- [blocks_delay_0_5, '0', blocks_add_xx_1, '6']
- [blocks_delay_0_6, '0', blocks_add_xx_1, '7']
- [blocks_delay_0_7, '0', blocks_add_xx_1, '8']
- [blocks_delay_0_8, '0', blocks_add_xx_1, '9']
- [blocks_delay_0_9, '0', blocks_add_xx_1, '10']
- [epy_block_0_0, '0', blocks_delay_0, '0']
- [epy_block_0_0_0, '0', blocks_delay_0_0, '0']
- [epy_block_0_0_1, '0', blocks_delay_0_1, '0']
- [epy_block_0_0_10, '0', blocks_delay_0_10, '0']
- [epy_block_0_0_11, '0', blocks_delay_0_11, '0']
- [epy_block_0_0_12, '0', blocks_delay_0_12, '0']
- [epy_block_0_0_13, '0', blocks_delay_0_13, '0']
- [epy_block_0_0_14, '0', blocks_delay_0_14, '0']
- [epy_block_0_0_14_0, '0', blocks_delay_0_14_0, '0']
- [epy_block_0_0_14_1, '0', blocks_delay_0_14_1, '0']
- [epy_block_0_0_14_10, '0', blocks_delay_0_14_10, '0']
- [epy_block_0_0_14_11, '0', blocks_delay_0_14_11, '0']
- [epy_block_0_0_14_12, '0', blocks_delay_0_14_12, '0']
- [epy_block_0_0_14_13, '0', blocks_delay_0_14_13, '0']
- [epy_block_0_0_14_14, '0', blocks_delay_0_14_14, '0']
- [epy_block_0_0_14_2, '0', blocks_delay_0_14_2, '0']
- [epy_block_0_0_14_3, '0', blocks_delay_0_14_3, '0']
- [epy_block_0_0_14_4, '0', blocks_delay_0_14_4, '0']
- [epy_block_0_0_14_5, '0', blocks_delay_0_14_5, '0']
- [epy_block_0_0_14_6, '0', blocks_delay_0_14_6, '0']
- [epy_block_0_0_14_7, '0', blocks_delay_0_14_7, '0']
- [epy_block_0_0_14_8, '0', blocks_delay_0_14_8, '0']
- [epy_block_0_0_14_9, '0', blocks_delay_0_14_9, '0']
- [epy_block_0_0_15, '0', blocks_delay_0_15, '0']
- [epy_block_0_0_2, '0', blocks_delay_0_2, '0']
- [epy_block_0_0_3, '0', blocks_delay_0_3, '0']
- [epy_block_0_0_4, '0', blocks_delay_0_4, '0']
- [epy_block_0_0_5, '0', blocks_delay_0_5, '0']
- [epy_block_0_0_6, '0', blocks_delay_0_6, '0']
- [epy_block_0_0_7, '0', blocks_delay_0_7, '0']
- [epy_block_0_0_8, '0', blocks_delay_0_8, '0']
- [epy_block_0_0_9, '0', blocks_delay_0_9, '0']
- [epy_block_1_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', pfb_channelizer_ccf_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_complex_to_mag_squared_0_0_0, '0']
- [pfb_channelizer_ccf_0, '10', blocks_complex_to_mag_squared_0_0_9, '0']
- [pfb_channelizer_ccf_0, '11', blocks_complex_to_mag_squared_0_0_10, '0']
- [pfb_channelizer_ccf_0, '12', blocks_complex_to_mag_squared_0_0_11, '0']
- [pfb_channelizer_ccf_0, '13', blocks_complex_to_mag_squared_0_0_12, '0']
- [pfb_channelizer_ccf_0, '14', blocks_complex_to_mag_squared_0_0_13, '0']
- [pfb_channelizer_ccf_0, '15', blocks_complex_to_mag_squared_0_0_14, '0']
- [pfb_channelizer_ccf_0, '16', blocks_complex_to_mag_squared_0_0_15, '0']
- [pfb_channelizer_ccf_0, '17', blocks_complex_to_mag_squared_0_0_16, '0']
- [pfb_channelizer_ccf_0, '18', blocks_complex_to_mag_squared_0_0_17, '0']
- [pfb_channelizer_ccf_0, '19', blocks_complex_to_mag_squared_0_0_18, '0']
- [pfb_channelizer_ccf_0, '2', blocks_complex_to_mag_squared_0_0_1, '0']
- [pfb_channelizer_ccf_0, '20', blocks_complex_to_mag_squared_0_0_19, '0']
- [pfb_channelizer_ccf_0, '21', blocks_complex_to_mag_squared_0_0_20, '0']
- [pfb_channelizer_ccf_0, '22', blocks_complex_to_mag_squared_0_0_21, '0']
- [pfb_channelizer_ccf_0, '23', blocks_complex_to_mag_squared_0_0_22, '0']
- [pfb_channelizer_ccf_0, '24', blocks_complex_to_mag_squared_0_0_23, '0']
- [pfb_channelizer_ccf_0, '25', blocks_complex_to_mag_squared_0_0_24, '0']
- [pfb_channelizer_ccf_0, '26', blocks_complex_to_mag_squared_0_0_25, '0']
- [pfb_channelizer_ccf_0, '27', blocks_complex_to_mag_squared_0_0_26, '0']
- [pfb_channelizer_ccf_0, '28', blocks_complex_to_mag_squared_0_0_27, '0']
- [pfb_channelizer_ccf_0, '29', blocks_complex_to_mag_squared_0_0_28, '0']
- [pfb_channelizer_ccf_0, '3', blocks_complex_to_mag_squared_0_0_2, '0']
- [pfb_channelizer_ccf_0, '30', blocks_complex_to_mag_squared_0_0_29, '0']
- [pfb_channelizer_ccf_0, '31', blocks_complex_to_mag_squared_0_0_30, '0']
- [pfb_channelizer_ccf_0, '4', blocks_complex_to_mag_squared_0_0_3, '0']
- [pfb_channelizer_ccf_0, '5', blocks_complex_to_mag_squared_0_0_4, '0']
- [pfb_channelizer_ccf_0, '6', blocks_complex_to_mag_squared_0_0_5, '0']
- [pfb_channelizer_ccf_0, '7', blocks_complex_to_mag_squared_0_0_6, '0']
- [pfb_channelizer_ccf_0, '8', blocks_complex_to_mag_squared_0_0_7, '0']
- [pfb_channelizer_ccf_0, '9', blocks_complex_to_mag_squared_0_0_8, '0']

metadata:
  file_format: 1
