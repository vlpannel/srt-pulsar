options:
  parameters:
    author: Viveca Pannell
    generate_options: hb
    id: pulsar_hier_onechannel
    output_language: python
    title: pulsar_hier_onechannel
  states: {}

blocks:
- name: baseline_time
  id: parameter
  parameters:
    label: FIR filter time
    type: eng_float
    value: '30'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: channel
  id: parameter
  parameters:
    label: Channel
    type: intx
    value: '0'
  states: {}
- name: deviations
  id: parameter
  parameters:
    label: Deviations
    type: eng_float
    value: '10'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import scipy
      from scipy import stats

      class filter_outlier_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Filter Outliers Block - passes data points through after replacing outliers with median value.

          Parameters
          ----------

          samp_rate : float, int
              Sample rate of incoming samples. Samples per second.

          time : float, int
              Amount of time to consider data. Seconds.

          deviations : int, float
              Number of deviations of variation from median that determines outlier.


          Notes
          -----

          Uses buffer of datapoints to calculate median and median absolute deviation. Outliers are points a number of deviations away from median (determined by parameter `deviation`). Size of buffer is numsamps where numsamps is the number of samples 
          """

          def __init__(self, samp_rate=(1000000/32), time=30, deviations=10):
              gr.sync_block.__init__(
                  self,
                  name='Filter Outliers',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.time = time
              self.deviations = deviations

              self.buffer = np.array([], dtype=np.float32)   # buffer to contain data
              self.data = np.array([], dtype=np.float32)  # data to pass out
              self.median = 0.    # median of data in buffer
              self.mad = 0.   # median absolute deviation of data in buffer
              

          def work(self, input_items, output_items):
              numsamps = self.samp_rate * self.time   # number of samples to store in buffer
              if self.buffer.size < numsamps:
                  self.buffer = np.append(self.buffer, input_items[0])
              else:
                  self.buffer = np.append(np.delete(self.buffer, range(input_items[0].size)), input_items[0][:])
              if self.buffer.size > numsamps:
                  self.buffer = np.delete(self.buffer, range(self.buffer.size - numsamps))

              self.data = input_items[0].copy()

              self.median = np.median(self.buffer)
              self.mad = scipy.stats.median_abs_deviation(self.buffer)

              self.data[np.where(np.absolute(self.data - self.median) > (self.deviations * self.mad))] = self.median
              
              output_items[0][:] = self.data[:]
              return len(output_items[0])
    deviations: deviations
    samp_rate: '31250.0'
    time: baseline_time
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import psrdynspec
      from psrdynspec import fold

      class fold_blk(gr.sync_block):
          """Block to perform folding (without importing but still [ab]using psrdynspec)"""

          def __init__(self, period=0.0333924123 , samp_rate=1000000/32, integration_time=10.):
              """
              Folding block - folds time series of power to find pulsars.

              Parameters
              ----------

              period : float
                  Folding period

              samp_rate : float
                  Sample rate of incoming samples

              integration_time : float
                  Number of seconds over which to integrate
              
              Notes
              -----
              Always outputs the last calculated phase vs. power profile.

              After calculating, immediately begins collecting data for a new calculation.
              
              """
              gr.sync_block.__init__(
                  self,
                  name='Fold',
                  in_sig=[np.float32],
                  out_sig=[(np.float32, 1024)]    # 1024 bins; if needing more/fewer bins, must also manually change this
              )
              self.period = float(period)
              self.samp_rate = float(samp_rate)
              self.integration_time = float(integration_time)

              self.bins = 1024
              self.profile = np.zeros(self.bins)
              self.data = np.array([], dtype=np.float32)

              self.fold_ts = fold.fold_ts

          def work(self, input_items, output_items):

              # aggregate data
              self.data = np.append(self.data, input_items[0])

              # if enough data collected
              if self.data.size >= self.samp_rate * self.integration_time:
                  times = np.arange(self.data.size) / self.samp_rate
                  self.profile = np.nan_to_num(self.fold_ts(self.data, times, self.period, self.bins, True)[0])
                  self.data = np.array([], dtype=np.float32)

              # always output the latest computed profile
              output_items[0][:] = np.array([self.profile] * output_items[0].shape[0])
              return len(output_items[0])
    integration_time: integration_time
    period: period
    samp_rate: samp_rate / num_channels
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import mitarspysigproc.filtertools as filtertools
  states: {}
- name: integration_time
  id: parameter
  parameters:
    label: Integration time
    type: eng_float
    value: '120'
  states: {}
- name: num_channels
  id: parameter
  parameters:
    label: Number of channels
    type: intx
    value: '32'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: '1024'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: period
  id: parameter
  parameters:
    label: Period
    type: eng_float
    value: '.03339'
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: channel
    decim: num_channels
    taps: filtertools.kaiser_coeffs(num_channels)
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '1000000'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, '0', pad_sink_0, '0']
- [pad_source_0, '0', pfb_decimator_ccf_0, '0']
- [pfb_decimator_ccf_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
