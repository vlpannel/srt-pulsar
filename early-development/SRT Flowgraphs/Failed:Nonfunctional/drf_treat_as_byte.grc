options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: drf_treatasbyte
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: int
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('Initial'), pmt.from_long(3))
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/treatasbyte_drf
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: int
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_1
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '4'
    type: int
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: int
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: misa-l2
    end0: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'False'
    top_level_dir: /Volumes/NO NAME/pulsar/2022-05-26/rf_data
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_int_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_int_to_float_1, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_int_to_float_1, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, qtgui_time_sink_x_0_0, in]
- [blocks_throttle_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_throttle_0, '0', blocks_int_to_float_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
