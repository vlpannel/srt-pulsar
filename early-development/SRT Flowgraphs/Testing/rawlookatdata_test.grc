options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: opt
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    comment: |-
      This channel (misa-l2) has
      two subchannels, so it outputs
      vectors of both. The vector
      must be split into separate
      streams (one for each
      subchannel).
    type: short
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: '"/Volumes/NO NAME/pulsar/2022-05-26/rf_data/misa-l2"'
    end: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'True'
    start: ''
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_source_0_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    alias: '"/Volumes/NO NAME/pulsar"'
    channel0: '"misa-l2"'
    end0: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'True'
    start0: ''
    throttle: 'True'
    top_level_dir: '"/Volumes/NO NAME/pulsar/2022-05-26/rf_data/"'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', qtgui_sink_x_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
