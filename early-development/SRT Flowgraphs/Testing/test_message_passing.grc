options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: test_cmd
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.from_float(1)
    period: '1000'
  states: {state: disabled}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: amp
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: amp
    target: amp
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_message_strobe_0, strobe, blocks_msgpair_to_var_0, inpair]
- [blocks_message_strobe_1, strobe, analog_sig_source_x_0, cmd]
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_strobe_1, set_msg]

metadata:
  file_format: 1
