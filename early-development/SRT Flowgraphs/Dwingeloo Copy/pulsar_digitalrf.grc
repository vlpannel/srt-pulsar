options:
  parameters:
    generate_options: no_gui
    id: drf_pulsar_flow_graph
    output_language: python
    run_options: run
    title: DRF Pulsar Processing (Folding)
  states: {}

blocks:
- name: channel_end
  id: variable
  parameters:
    value: '1653602399999999'
  states: {}
- name: channel_start
  id: variable
  parameters:
    value: '1653595200000000'
  states: {}
- name: integration
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samples
  id: variable
  parameters:
    value: int(tlen*samp_rate)
  states: {}
- name: tlen
  id: variable
  parameters:
    value: 1/29.7
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    comment: |-
      Works, creating .bin file
      ... or any kind of file (text file)
    detached: 'False'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('Initial'), pmt.from_long(3))
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/Testing Output Files/drf_output_sub1
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: float
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    comment: |-
      Works, creating .bin file
      ... or any kind of file (text file)
    detached: 'False'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('Initial'), pmt.from_long(3))
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/Testing Output Files/drf_output_sub2
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Creates empty files?
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/Testing Output Files/drf_output_1
    type: float
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '10'
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '10'
    type: float
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '83'
    type: float
    vlen: samples
  states: {}
- name: blocks_integrate_xx_1_0
  id: blocks_integrate_xx
  parameters:
    decim: '83'
    type: float
    vlen: '714520'
  states: {}
- name: blocks_integrate_xx_2
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
  states: {}
- name: blocks_integrate_xx_2_0
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
  states: {}
- name: blocks_interleaved_short_to_complex_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767.0'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_2_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: samples
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '714520'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: samples
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '714520'
    type: float
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    comment: |-
      This channel (misa-l2) has
      two subchannels, so it outputs
      vectors of both. The vector
      must be split into separate
      streams (one for each
      subchannel).
    type: short
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: '''/Volumes/NO NAME/pulsar/2022-05-26/rf_data/misa-l2'''
    end: ''
    gapless: 'True'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'True'
    start: ''
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: f32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: ''
    uuid: ''
    vlen: '1'
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: '''misa-l2'''
    comment: |-
      Puts out either one-value
      streams or a vector with as
      many values as there are
      subchannels.

      Note: MUST put bounds
      on these blocks (just letting
      it default to a value doesn't
      cut it)
    end0: channel_end
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'True'
    start0: channel_start
    throttle: 'False'
    top_level_dir: '''/Volumes/NO NAME/pulsar/2022-05-26/rf_data'''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Same DSP, just for
      other stream.
    note: duplicate DSP
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_integrate_xx_1, '0', blocks_vector_to_stream_1, '0']
- [blocks_integrate_xx_1_0, '0', blocks_vector_to_stream_1_0, '0']
- [blocks_integrate_xx_2, '0', blocks_file_meta_sink_0, '0']
- [blocks_integrate_xx_2, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_2_0, '0', blocks_file_meta_sink_0_0, '0']
- [blocks_interleaved_short_to_complex_2, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_2_0, '0', blocks_throttle_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_integrate_xx_1, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_integrate_xx_1_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_integrate_xx_2, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_integrate_xx_2_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_interleaved_short_to_complex_2, '0']
- [blocks_vector_to_streams_0, '1', blocks_interleaved_short_to_complex_2_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_vector_to_streams_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
