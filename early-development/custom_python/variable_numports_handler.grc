options:
  parameters:
    author: Viveca Pannell
    generate_options: hb
    id: variable_numports_handler*
    output_language: python
    title: Variable Number of Ports (32 Max)**
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(0)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(1)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(2)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(3)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(4)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_10
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(13)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_11
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(14)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_12
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(15)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_13
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(16)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_14
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(17)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(18)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(19)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(20)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_10
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(29)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_11
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(30)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_12
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(31)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(21)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(22)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_4
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(23)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_5
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(24)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_6
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(25)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_7
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(26)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_8
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(27)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_9
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(28)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(5)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(6)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_4
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(7)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_5
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(8)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_6
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(9)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_7
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(10)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_8
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(11)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_9
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: criterion(12)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: criterion
  id: parameter
  parameters:
    value: 'lambda x: int(x in listed)'
  states: {}
- name: listed
  id: parameter
  parameters:
    value: '[]'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Still have to make this able to handle bus ports
    note: work in progress
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out0
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out1
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: out2
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_10
  id: pad_sink
  parameters:
    label: out11
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_11
  id: pad_sink
  parameters:
    label: out12
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_12
  id: pad_sink
  parameters:
    label: out13
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_13
  id: pad_sink
  parameters:
    label: out14
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_14
  id: pad_sink
  parameters:
    label: out15
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_15
  id: pad_sink
  parameters:
    label: out16
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_16
  id: pad_sink
  parameters:
    label: out17
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_17
  id: pad_sink
  parameters:
    label: out18
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_18
  id: pad_sink
  parameters:
    label: out19
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_19
  id: pad_sink
  parameters:
    label: out20
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_2
  id: pad_sink
  parameters:
    label: out3
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_20
  id: pad_sink
  parameters:
    label: out21
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_21
  id: pad_sink
  parameters:
    label: out22
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_22
  id: pad_sink
  parameters:
    label: out23
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_23
  id: pad_sink
  parameters:
    label: out24
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_24
  id: pad_sink
  parameters:
    label: out25
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_25
  id: pad_sink
  parameters:
    label: out26
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_26
  id: pad_sink
  parameters:
    label: out27
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_27
  id: pad_sink
  parameters:
    label: out28
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_28
  id: pad_sink
  parameters:
    label: out29
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_29
  id: pad_sink
  parameters:
    label: out30
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_3
  id: pad_sink
  parameters:
    label: out4
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_30
  id: pad_sink
  parameters:
    label: out31
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_4
  id: pad_sink
  parameters:
    label: out5
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_5
  id: pad_sink
  parameters:
    label: out6
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_6
  id: pad_sink
  parameters:
    label: out7
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_7
  id: pad_sink
  parameters:
    label: out8
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_8
  id: pad_sink
  parameters:
    label: out9
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_9
  id: pad_sink
  parameters:
    label: out10
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9
  id: pad_source
  parameters:
    label: in0
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_0
  id: pad_source
  parameters:
    label: in1
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_1
  id: pad_source
  parameters:
    label: in2
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_10
  id: pad_source
  parameters:
    label: in11
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_11
  id: pad_source
  parameters:
    label: in12
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_12
  id: pad_source
  parameters:
    label: in13
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_13
  id: pad_source
  parameters:
    label: in14
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_14
  id: pad_source
  parameters:
    label: in15
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_15
  id: pad_source
  parameters:
    label: in16
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_16
  id: pad_source
  parameters:
    label: in17
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_17
  id: pad_source
  parameters:
    label: in18
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_18
  id: pad_source
  parameters:
    label: in19
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_19
  id: pad_source
  parameters:
    label: in20
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_2
  id: pad_source
  parameters:
    label: in3
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_20
  id: pad_source
  parameters:
    label: in21
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_21
  id: pad_source
  parameters:
    label: in22
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_22
  id: pad_source
  parameters:
    label: in23
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_23
  id: pad_source
  parameters:
    label: in24
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_24
  id: pad_source
  parameters:
    label: in25
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_25
  id: pad_source
  parameters:
    label: in26
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_26
  id: pad_source
  parameters:
    label: in27
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_27
  id: pad_source
  parameters:
    label: in28
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_28
  id: pad_source
  parameters:
    label: in29
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_29
  id: pad_source
  parameters:
    label: in30
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_3
  id: pad_source
  parameters:
    label: in4
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_30
  id: pad_source
  parameters:
    label: in31
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_4
  id: pad_source
  parameters:
    label: in5
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_5
  id: pad_source
  parameters:
    label: in6
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_6
  id: pad_source
  parameters:
    label: in7
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_7
  id: pad_source
  parameters:
    label: in8
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_8
  id: pad_source
  parameters:
    label: in9
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_9
  id: pad_source
  parameters:
    label: in10
    optional: 'True'
    type: float
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_selector_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_10, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_11, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_12, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_13, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_14, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_10, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_11, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_12, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_2, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_3, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_4, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_5, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_6, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_7, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_8, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_9, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_2, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_3, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_4, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_5, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_6, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_7, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_8, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_9, '0']
- [blocks_selector_0, '0', pad_sink_0, '0']
- [blocks_selector_0_0, '0', pad_sink_0_0, '0']
- [blocks_selector_0_1, '0', pad_sink_0_1, '0']
- [blocks_selector_0_1_0, '0', pad_sink_0_2, '0']
- [blocks_selector_0_1_1, '0', pad_sink_0_3, '0']
- [blocks_selector_0_1_10, '0', pad_sink_0_12, '0']
- [blocks_selector_0_1_11, '0', pad_sink_0_13, '0']
- [blocks_selector_0_1_12, '0', pad_sink_0_14, '0']
- [blocks_selector_0_1_13, '0', pad_sink_0_15, '0']
- [blocks_selector_0_1_14, '0', pad_sink_0_16, '0']
- [blocks_selector_0_1_15, '0', pad_sink_0_17, '0']
- [blocks_selector_0_1_15_0, '0', pad_sink_0_18, '0']
- [blocks_selector_0_1_15_1, '0', pad_sink_0_19, '0']
- [blocks_selector_0_1_15_10, '0', pad_sink_0_28, '0']
- [blocks_selector_0_1_15_11, '0', pad_sink_0_29, '0']
- [blocks_selector_0_1_15_12, '0', pad_sink_0_30, '0']
- [blocks_selector_0_1_15_2, '0', pad_sink_0_20, '0']
- [blocks_selector_0_1_15_3, '0', pad_sink_0_21, '0']
- [blocks_selector_0_1_15_4, '0', pad_sink_0_22, '0']
- [blocks_selector_0_1_15_5, '0', pad_sink_0_23, '0']
- [blocks_selector_0_1_15_6, '0', pad_sink_0_24, '0']
- [blocks_selector_0_1_15_7, '0', pad_sink_0_25, '0']
- [blocks_selector_0_1_15_8, '0', pad_sink_0_26, '0']
- [blocks_selector_0_1_15_9, '0', pad_sink_0_27, '0']
- [blocks_selector_0_1_2, '0', pad_sink_0_4, '0']
- [blocks_selector_0_1_3, '0', pad_sink_0_5, '0']
- [blocks_selector_0_1_4, '0', pad_sink_0_6, '0']
- [blocks_selector_0_1_5, '0', pad_sink_0_7, '0']
- [blocks_selector_0_1_6, '0', pad_sink_0_8, '0']
- [blocks_selector_0_1_7, '0', pad_sink_0_9, '0']
- [blocks_selector_0_1_8, '0', pad_sink_0_10, '0']
- [blocks_selector_0_1_9, '0', pad_sink_0_11, '0']
- [pad_source_0_0_9, '0', blocks_selector_0, '1']
- [pad_source_0_0_9_0, '0', blocks_selector_0_0, '1']
- [pad_source_0_0_9_1, '0', blocks_selector_0_1, '1']
- [pad_source_0_0_9_10, '0', blocks_selector_0_1_8, '1']
- [pad_source_0_0_9_11, '0', blocks_selector_0_1_9, '1']
- [pad_source_0_0_9_12, '0', blocks_selector_0_1_10, '1']
- [pad_source_0_0_9_13, '0', blocks_selector_0_1_11, '1']
- [pad_source_0_0_9_14, '0', blocks_selector_0_1_12, '1']
- [pad_source_0_0_9_15, '0', blocks_selector_0_1_13, '1']
- [pad_source_0_0_9_16, '0', blocks_selector_0_1_14, '1']
- [pad_source_0_0_9_17, '0', blocks_selector_0_1_15, '1']
- [pad_source_0_0_9_18, '0', blocks_selector_0_1_15_0, '1']
- [pad_source_0_0_9_19, '0', blocks_selector_0_1_15_1, '1']
- [pad_source_0_0_9_2, '0', blocks_selector_0_1_0, '1']
- [pad_source_0_0_9_20, '0', blocks_selector_0_1_15_2, '1']
- [pad_source_0_0_9_21, '0', blocks_selector_0_1_15_3, '1']
- [pad_source_0_0_9_22, '0', blocks_selector_0_1_15_4, '1']
- [pad_source_0_0_9_23, '0', blocks_selector_0_1_15_5, '1']
- [pad_source_0_0_9_24, '0', blocks_selector_0_1_15_6, '1']
- [pad_source_0_0_9_25, '0', blocks_selector_0_1_15_7, '1']
- [pad_source_0_0_9_26, '0', blocks_selector_0_1_15_8, '1']
- [pad_source_0_0_9_27, '0', blocks_selector_0_1_15_9, '1']
- [pad_source_0_0_9_28, '0', blocks_selector_0_1_15_10, '1']
- [pad_source_0_0_9_29, '0', blocks_selector_0_1_15_11, '1']
- [pad_source_0_0_9_3, '0', blocks_selector_0_1_1, '1']
- [pad_source_0_0_9_30, '0', blocks_selector_0_1_15_12, '1']
- [pad_source_0_0_9_4, '0', blocks_selector_0_1_2, '1']
- [pad_source_0_0_9_5, '0', blocks_selector_0_1_3, '1']
- [pad_source_0_0_9_6, '0', blocks_selector_0_1_4, '1']
- [pad_source_0_0_9_7, '0', blocks_selector_0_1_5, '1']
- [pad_source_0_0_9_8, '0', blocks_selector_0_1_6, '1']
- [pad_source_0_0_9_9, '0', blocks_selector_0_1_7, '1']

metadata:
  file_format: 1
