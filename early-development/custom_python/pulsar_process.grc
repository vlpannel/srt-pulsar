options:
  parameters:
    author: Viveca Pannell
    generate_options: hb
    id: pulsar_process
    output_language: python
    title: Pulsar Processing
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_channels
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: num_channels
    type: complex
  states: {bus_sink: true}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: num_channels
    type: float
  states: {bus_source: true}
- name: num_channels
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: '1024'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: parameter_0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: num_channels
    osr: '1.0'
    taps: taps
  states: {bus_source: true}
- name: pulsar_dedisp_incoherent_0
  id: pulsar_dedisp_incoherent
  parameters:
    bandwidth: '1'
    center_freq: '440'
    channels: '[]'
    dm: '56.77118'
    num_channels: '32'
    samp_rate: '1000000'
  states: {}
- name: pulsar_fold_0
  id: pulsar_fold
  parameters:
    integration_time: '60'
    period: '0.033397'
    samp_rate: 1000000/32
  states: {}
- name: pulsar_medianfilter_0
  id: pulsar_medianfilter
  parameters:
    baseline_time: '30'
    deviations: '10'
    samp_rate: 1000000/32
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '1000000'
  states: {}
- name: taps
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_streams_0, '32', pulsar_medianfilter_0, '0']
- [pad_source_0, '0', pfb_channelizer_ccf_0, '0']
- [pfb_channelizer_ccf_0, '32', blocks_streams_to_vector_0, '32']
- [pulsar_dedisp_incoherent_0, '0', pulsar_fold_0, '0']
- [pulsar_fold_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
