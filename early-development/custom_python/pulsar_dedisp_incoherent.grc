options:
  parameters:
    author: Viveca Pannell
    generate_options: hb
    id: pulsar_dedisp_incoherent
    output_language: python
    title: Dedisperse (Incoherent)
  states: {}

blocks:
- name: bandwidth
  id: parameter
  parameters:
    label: Bandwidth (MHz)
    type: eng_float
    value: '1'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '32'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 0, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 1, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 2, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_10
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 11, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_11
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 12, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_12
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 13, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_13
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 14, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 15, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_0
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 17, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_1
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 18, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_10
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 27, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_11
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 28, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_12
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 29, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_13
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 30, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_14
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 31, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_2
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 19, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_3
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 20, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_4
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 21, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_5
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 22, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_6
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 23, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_7
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 24, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_8
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 25, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_14_9
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 26, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_15
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 16, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 3, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 4, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 5, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 6, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 7, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_7
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 8, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_8
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 9, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_delay_0_9
  id: blocks_delay
  parameters:
    delay: inco_dedisp.dedisperse(center_freq, bandwidth, num_channels, 10, dm, samp_rate/32)
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(0 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(1 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(2 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(3 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(4 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_10
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(13 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_11
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(14 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_12
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(15 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_13
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(16 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_14
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(17 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(18 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(19 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(20 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_10
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(29 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_11
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(30 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_12
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(31 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(21 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(22 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_4
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(23 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_5
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(24 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_6
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(25 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_7
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(26 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_8
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(27 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_15_9
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(28 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(5 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(6 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_4
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(7 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_5
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(8 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_6
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(9 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_7
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(10 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_8
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(11 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1_9
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(12 in channels)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center Frequency (MHz)
    type: eng_float
    value: '440'
  states: {}
- name: channels
  id: parameter
  parameters:
    label: Channels Connected
    value: '[]'
  states: {}
- name: dm
  id: parameter
  parameters:
    label: Dispersion measure
    type: eng_float
    value: '56.77118'
  states: {}
- name: inco_dedisp
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\ndef dedisperse(center_freq, bandwidth, num_channels, channel, dm, samp_rate):\n    '''\n    Delay channel be specified amount given frequencies and dispersion measure. Assumes standard channel mapping and even number of channels. Aligns all channels with lowest channel (for delay purposes).\n\n    Parameters\n    ----------\n\n    center_freq : float\n        Center frequency in MHz\n\n    bandwidth : float\n        Total bandwidth of signal reception in MHz\n\n    num_channels : int\n        Number of channels into which bandwidth is divided (equally)\n\n    channel : int\n        Which channel is being dedispersed (0 is at center frequency)\n\n    dm : float\n        Dispersion measure of pulsar (in pc cm^-3)\n\n    samp_rate : float\n        Sample rate of incoming samples (samples per second)\n    '''\n\n    kdm = 4149.    # dispersion measure constant (converted from GHz^2 to MHz^2 and ms to s)\n\n    # find frequencies of lowest channel and current channel\n    channel_width = bandwidth / num_channels\n    v2 = center_freq - (bandwidth/2)     # lowest frequency\n    if channel <= num_channels/2:       # current channel\n        v1 = center_freq + (channel)*channel_width\n    else:\n        v1 = center_freq - (num_channels - channel)*channel_width\n\n    # find amount of dispersion\n    time_delta = kdm * dm * ((1/(v2**2)) - (1/(v1**2)))\n    return int(time_delta * samp_rate)\n    \n"
  states: {}
- name: num_channels
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0_0_9
  id: pad_source
  parameters:
    label: in0
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_0
  id: pad_source
  parameters:
    label: in1
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_1
  id: pad_source
  parameters:
    label: in2
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_10
  id: pad_source
  parameters:
    label: in11
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_11
  id: pad_source
  parameters:
    label: in12
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_12
  id: pad_source
  parameters:
    label: in13
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_13
  id: pad_source
  parameters:
    label: in14
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_14
  id: pad_source
  parameters:
    label: in15
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_15
  id: pad_source
  parameters:
    label: in16
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_16
  id: pad_source
  parameters:
    label: in17
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_17
  id: pad_source
  parameters:
    label: in18
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_18
  id: pad_source
  parameters:
    label: in19
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_19
  id: pad_source
  parameters:
    label: in20
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_2
  id: pad_source
  parameters:
    label: in3
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_20
  id: pad_source
  parameters:
    label: in21
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_21
  id: pad_source
  parameters:
    label: in22
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_22
  id: pad_source
  parameters:
    label: in23
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_23
  id: pad_source
  parameters:
    label: in24
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_24
  id: pad_source
  parameters:
    label: in25
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_25
  id: pad_source
  parameters:
    label: in26
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_26
  id: pad_source
  parameters:
    label: in27
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_27
  id: pad_source
  parameters:
    label: in28
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_28
  id: pad_source
  parameters:
    label: in29
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_29
  id: pad_source
  parameters:
    label: in30
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_3
  id: pad_source
  parameters:
    label: in4
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_30
  id: pad_source
  parameters:
    label: in31
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_4
  id: pad_source
  parameters:
    label: in5
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_5
  id: pad_source
  parameters:
    label: in6
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_6
  id: pad_source
  parameters:
    label: in7
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_7
  id: pad_source
  parameters:
    label: in8
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_8
  id: pad_source
  parameters:
    label: in9
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0_0_9_9
  id: pad_source
  parameters:
    label: in10
    optional: 'True'
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '1000000'
  states: {}

connections:
- [blocks_add_xx_1, '0', pad_sink_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_1, '1']
- [blocks_delay_0_1, '0', blocks_add_xx_1, '2']
- [blocks_delay_0_10, '0', blocks_add_xx_1, '11']
- [blocks_delay_0_11, '0', blocks_add_xx_1, '12']
- [blocks_delay_0_12, '0', blocks_add_xx_1, '13']
- [blocks_delay_0_13, '0', blocks_add_xx_1, '14']
- [blocks_delay_0_14, '0', blocks_add_xx_1, '15']
- [blocks_delay_0_14_0, '0', blocks_add_xx_1, '17']
- [blocks_delay_0_14_1, '0', blocks_add_xx_1, '18']
- [blocks_delay_0_14_10, '0', blocks_add_xx_1, '27']
- [blocks_delay_0_14_11, '0', blocks_add_xx_1, '28']
- [blocks_delay_0_14_12, '0', blocks_add_xx_1, '29']
- [blocks_delay_0_14_13, '0', blocks_add_xx_1, '30']
- [blocks_delay_0_14_14, '0', blocks_add_xx_1, '31']
- [blocks_delay_0_14_2, '0', blocks_add_xx_1, '19']
- [blocks_delay_0_14_3, '0', blocks_add_xx_1, '20']
- [blocks_delay_0_14_4, '0', blocks_add_xx_1, '21']
- [blocks_delay_0_14_5, '0', blocks_add_xx_1, '22']
- [blocks_delay_0_14_6, '0', blocks_add_xx_1, '23']
- [blocks_delay_0_14_7, '0', blocks_add_xx_1, '24']
- [blocks_delay_0_14_8, '0', blocks_add_xx_1, '25']
- [blocks_delay_0_14_9, '0', blocks_add_xx_1, '26']
- [blocks_delay_0_15, '0', blocks_add_xx_1, '16']
- [blocks_delay_0_2, '0', blocks_add_xx_1, '3']
- [blocks_delay_0_3, '0', blocks_add_xx_1, '4']
- [blocks_delay_0_4, '0', blocks_add_xx_1, '5']
- [blocks_delay_0_5, '0', blocks_add_xx_1, '6']
- [blocks_delay_0_6, '0', blocks_add_xx_1, '7']
- [blocks_delay_0_7, '0', blocks_add_xx_1, '8']
- [blocks_delay_0_8, '0', blocks_add_xx_1, '9']
- [blocks_delay_0_9, '0', blocks_add_xx_1, '10']
- [blocks_null_source_0, '0', blocks_selector_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_10, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_11, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_12, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_13, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_14, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_10, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_11, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_12, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_2, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_3, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_4, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_5, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_6, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_7, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_8, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_15_9, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_2, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_3, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_4, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_5, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_6, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_7, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_8, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1_9, '0']
- [blocks_selector_0, '0', blocks_delay_0, '0']
- [blocks_selector_0_0, '0', blocks_delay_0_0, '0']
- [blocks_selector_0_1, '0', blocks_delay_0_1, '0']
- [blocks_selector_0_1_0, '0', blocks_delay_0_2, '0']
- [blocks_selector_0_1_1, '0', blocks_delay_0_3, '0']
- [blocks_selector_0_1_10, '0', blocks_delay_0_12, '0']
- [blocks_selector_0_1_11, '0', blocks_delay_0_13, '0']
- [blocks_selector_0_1_12, '0', blocks_delay_0_14, '0']
- [blocks_selector_0_1_13, '0', blocks_delay_0_15, '0']
- [blocks_selector_0_1_14, '0', blocks_delay_0_14_0, '0']
- [blocks_selector_0_1_15, '0', blocks_delay_0_14_1, '0']
- [blocks_selector_0_1_15_0, '0', blocks_delay_0_14_2, '0']
- [blocks_selector_0_1_15_1, '0', blocks_delay_0_14_3, '0']
- [blocks_selector_0_1_15_10, '0', blocks_delay_0_14_12, '0']
- [blocks_selector_0_1_15_11, '0', blocks_delay_0_14_13, '0']
- [blocks_selector_0_1_15_12, '0', blocks_delay_0_14_14, '0']
- [blocks_selector_0_1_15_2, '0', blocks_delay_0_14_4, '0']
- [blocks_selector_0_1_15_3, '0', blocks_delay_0_14_5, '0']
- [blocks_selector_0_1_15_4, '0', blocks_delay_0_14_6, '0']
- [blocks_selector_0_1_15_5, '0', blocks_delay_0_14_7, '0']
- [blocks_selector_0_1_15_6, '0', blocks_delay_0_14_8, '0']
- [blocks_selector_0_1_15_7, '0', blocks_delay_0_14_9, '0']
- [blocks_selector_0_1_15_8, '0', blocks_delay_0_14_10, '0']
- [blocks_selector_0_1_15_9, '0', blocks_delay_0_14_11, '0']
- [blocks_selector_0_1_2, '0', blocks_delay_0_4, '0']
- [blocks_selector_0_1_3, '0', blocks_delay_0_5, '0']
- [blocks_selector_0_1_4, '0', blocks_delay_0_6, '0']
- [blocks_selector_0_1_5, '0', blocks_delay_0_7, '0']
- [blocks_selector_0_1_6, '0', blocks_delay_0_8, '0']
- [blocks_selector_0_1_7, '0', blocks_delay_0_9, '0']
- [blocks_selector_0_1_8, '0', blocks_delay_0_10, '0']
- [blocks_selector_0_1_9, '0', blocks_delay_0_11, '0']
- [pad_source_0_0_9, '0', blocks_selector_0, '1']
- [pad_source_0_0_9_0, '0', blocks_selector_0_0, '1']
- [pad_source_0_0_9_1, '0', blocks_selector_0_1, '1']
- [pad_source_0_0_9_10, '0', blocks_selector_0_1_8, '1']
- [pad_source_0_0_9_11, '0', blocks_selector_0_1_9, '1']
- [pad_source_0_0_9_12, '0', blocks_selector_0_1_10, '1']
- [pad_source_0_0_9_13, '0', blocks_selector_0_1_11, '1']
- [pad_source_0_0_9_14, '0', blocks_selector_0_1_12, '1']
- [pad_source_0_0_9_15, '0', blocks_selector_0_1_13, '1']
- [pad_source_0_0_9_16, '0', blocks_selector_0_1_14, '1']
- [pad_source_0_0_9_17, '0', blocks_selector_0_1_15, '1']
- [pad_source_0_0_9_18, '0', blocks_selector_0_1_15_0, '1']
- [pad_source_0_0_9_19, '0', blocks_selector_0_1_15_1, '1']
- [pad_source_0_0_9_2, '0', blocks_selector_0_1_0, '1']
- [pad_source_0_0_9_20, '0', blocks_selector_0_1_15_2, '1']
- [pad_source_0_0_9_21, '0', blocks_selector_0_1_15_3, '1']
- [pad_source_0_0_9_22, '0', blocks_selector_0_1_15_4, '1']
- [pad_source_0_0_9_23, '0', blocks_selector_0_1_15_5, '1']
- [pad_source_0_0_9_24, '0', blocks_selector_0_1_15_6, '1']
- [pad_source_0_0_9_25, '0', blocks_selector_0_1_15_7, '1']
- [pad_source_0_0_9_26, '0', blocks_selector_0_1_15_8, '1']
- [pad_source_0_0_9_27, '0', blocks_selector_0_1_15_9, '1']
- [pad_source_0_0_9_28, '0', blocks_selector_0_1_15_10, '1']
- [pad_source_0_0_9_29, '0', blocks_selector_0_1_15_11, '1']
- [pad_source_0_0_9_3, '0', blocks_selector_0_1_1, '1']
- [pad_source_0_0_9_30, '0', blocks_selector_0_1_15_12, '1']
- [pad_source_0_0_9_4, '0', blocks_selector_0_1_2, '1']
- [pad_source_0_0_9_5, '0', blocks_selector_0_1_3, '1']
- [pad_source_0_0_9_6, '0', blocks_selector_0_1_4, '1']
- [pad_source_0_0_9_7, '0', blocks_selector_0_1_5, '1']
- [pad_source_0_0_9_8, '0', blocks_selector_0_1_6, '1']
- [pad_source_0_0_9_9, '0', blocks_selector_0_1_7, '1']

metadata:
  file_format: 1
