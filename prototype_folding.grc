options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: prototype_folding
    output_language: python
    title: 'Prototype Flowgraph: Folding'
  states: {}

blocks:
- name: bins
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: channel
  id: variable
  parameters:
    comment: |-
      Channel
      name
    value: '''ch0'''
  states: {}
- name: nsamps
  id: variable
  parameters:
    value: int(secs*sr)
  states: {}
- name: num_subchannels
  id: variable
  parameters:
    comment: |-
      Number of subchannels
      in channel
    value: '1'
  states: {}
- name: period
  id: variable
  parameters:
    comment: |-
      Pulsar and folding
      period (may later
      change to be
      different?)
    value: 33.5028583*1e-3
  states: {}
- name: pfb_data
  id: variable
  parameters:
    comment: |-
      Top level directory for stored
      DRF data
    value: '"/Users/vivelpanel/pfbdata"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: secs
  id: variable
  parameters:
    value: '120'
  states: {}
- name: sr
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_msg_meta_to_pair_0
  id: blocks_msg_meta_to_pair
  parameters:
    keyin: '''samples_per_second'''
    keyout: '''samp_rate'''
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    comment: Sample rate according to DRF file
    target: sr
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: bins
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: bins
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: bins
  states: {}
- name: blocks_null_sink_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: bins
  states: {}
- name: blocks_null_sink_1_0_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: bins
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: bins
  states: {}
- name: blocks_null_sink_1_1_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: bins
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    comment: |-
      FIX ME, TEMPORARY: Connecting other
      channels to null sink to just isolate
      center-most frequencies (for testing
      purposes)
    num_inputs: '22'
    type: complex
    vlen: nsamps
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_2
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_3_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_4
  id: blocks_stream_to_vector
  parameters:
    num_items: nsamps
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Controlling flow (no hardware here)
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(120e6), samp_rate=32e3, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(120e6), samp_rate=32e3, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(120e6), samp_rate=32e3, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(120e6), samp_rate=32e3, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(120e6), samp_rate=32e3, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(120e6), samp_rate=32e3, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    Nbins: bins
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #from psrdynspec.modules.fold import execute_plan, fold_ts

      class blk(gr.sync_block):
          """
          Pulsar folding block - takes in time series of a single channel and folds it over the pulsar period.

          Outputs a vector of length Nbins which is the number of counts per phase bin (this can be used for plotting).

          
          Parameters
          ----------

          nsamps : int
              Number of samples coming in; the length of the vector passed in

          samp_rate : float
              Sample rate of data (taken from metadata)

          Nbins : int
              Number of phase bins in which to sort samples

          pfold : float
              Folding period (should be same or similar to period of pulsar)
          """

          def __init__(self, nsamps=int(120e6), samp_rate=32e3, Nbins=1024, pfold=33.5028583*1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folding',   # will show up in GRC
                  in_sig=[(np.complex64, nsamps)],
                  out_sig=[(np.float32, Nbins), (np.float32, Nbins)]
              )
              '''
              Initializes pulsar folding block

              Parameters
              ----------

              nsamps : int
                  Number of samples coming in-- the length of the vector passed in

              samp_rate : float
                  Sample rate of data (taken from metadata)

              Nbins : int
                  Number of phase bins in which to sort samples

              pfold : float
                  Folding period (should be same or similar to period of pulsar)
              '''
              self.nsamps = nsamps
              self.samp_rate = samp_rate
              self.Nbins = Nbins
              self.pfold = pfold

              self.times = np.arange(nsamps)/samp_rate

          def work(self, input_items, output_items):

              # folding
              self.profile, self.phibin_centers, self.counts = fold_ts(np.abs(input_items[0])**2, self.times, self.pfold, self.Nbins, True)
              
              output_items[0] = self.times
              output_items[1] = self.profile
              return len(output_items[0])
    nsamps: nsamps
    pfold: period
    samp_rate: samp_rate
  states: {}
- name: gr_digital_rf_digital_rf_source_0_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: ch0
    channel1: ch1
    channel10: ch10
    channel11: ch11
    channel12: ch12
    channel13: ch13
    channel14: ch14
    channel15: ch15
    channel16: ch16
    channel17: ch17
    channel18: ch18
    channel19: ch19
    channel2: ch2
    channel20: ch20
    channel21: ch21
    channel22: ch22
    channel23: ch23
    channel24: ch24
    channel25: ch25
    channel26: ch26
    channel27: ch27
    channel28: ch28
    channel3: ch3
    channel4: ch4
    channel5: ch5
    channel6: ch6
    channel7: ch7
    channel8: ch8
    channel9: ch9
    end0: ''
    end1: ''
    end10: ''
    end11: ''
    end12: ''
    end13: ''
    end14: ''
    end15: ''
    end16: ''
    end17: ''
    end18: ''
    end19: ''
    end2: ''
    end20: ''
    end21: ''
    end22: ''
    end23: ''
    end24: ''
    end25: ''
    end26: ''
    end27: ''
    end28: ''
    end3: ''
    end4: ''
    end5: ''
    end6: ''
    end7: ''
    end8: ''
    end9: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '29'
    repeat: 'False'
    start0: ''
    start1: ''
    start10: ''
    start11: ''
    start12: ''
    start13: ''
    start14: ''
    start15: ''
    start16: ''
    start17: ''
    start18: ''
    start19: ''
    start2: ''
    start20: ''
    start21: ''
    start22: ''
    start23: ''
    start24: ''
    start25: ''
    start26: ''
    start27: ''
    start28: ''
    start3: ''
    start4: ''
    start5: ''
    start6: ''
    start7: ''
    start8: ''
    start9: ''
    throttle: 'False'
    top_level_dir: pfb_data
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Remember to pay attention
      to connections here if
      subchannels change!
    note: Subchannels change
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      Remember to alter data types
      if file outputs different type!
    note: Assumes Complex (complex32)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: bins
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: bins
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: bins
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: bins
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_0_1
  id: qtgui_vector_sink_f
  parameters:
    vlen: bins
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    vlen: bins
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: bins
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_msg_meta_to_pair_0, outpair, blocks_msgpair_to_var_0, inpair]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_null_sink_2, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', blocks_null_sink_2, '6']
- [blocks_stream_to_vector_0_0_0_0_0, '0', blocks_null_sink_2, '18']
- [blocks_stream_to_vector_0_0_0_0_0_0, '0', epy_block_0_0_1, '0']
- [blocks_stream_to_vector_0_0_0_1, '0', blocks_null_sink_2, '12']
- [blocks_stream_to_vector_0_0_1, '0', blocks_null_sink_2, '3']
- [blocks_stream_to_vector_0_0_1_0, '0', blocks_null_sink_2, '15']
- [blocks_stream_to_vector_0_0_2, '0', blocks_null_sink_2, '9']
- [blocks_stream_to_vector_0_1, '0', epy_block_0_1, '0']
- [blocks_stream_to_vector_0_1_0, '0', blocks_null_sink_2, '1']
- [blocks_stream_to_vector_0_1_0_0, '0', blocks_null_sink_2, '7']
- [blocks_stream_to_vector_0_1_0_0_0, '0', blocks_null_sink_2, '19']
- [blocks_stream_to_vector_0_1_0_0_0_0, '0', epy_block_0_1_0, '0']
- [blocks_stream_to_vector_0_1_0_0_0_0_0, '0', epy_block_0_0_0_0, '0']
- [blocks_stream_to_vector_0_1_0_1, '0', blocks_null_sink_2, '13']
- [blocks_stream_to_vector_0_1_1, '0', blocks_null_sink_2, '4']
- [blocks_stream_to_vector_0_1_1_0, '0', blocks_null_sink_2, '16']
- [blocks_stream_to_vector_0_1_1_0_0, '0', blocks_null_sink_2, '20']
- [blocks_stream_to_vector_0_1_2, '0', blocks_null_sink_2, '10']
- [blocks_stream_to_vector_0_2, '0', epy_block_0_0_0, '0']
- [blocks_stream_to_vector_0_2_0, '0', blocks_null_sink_2, '5']
- [blocks_stream_to_vector_0_2_0_0, '0', blocks_null_sink_2, '17']
- [blocks_stream_to_vector_0_2_0_0_0, '0', blocks_null_sink_2, '21']
- [blocks_stream_to_vector_0_2_1, '0', blocks_null_sink_2, '11']
- [blocks_stream_to_vector_0_3, '0', blocks_null_sink_2, '2']
- [blocks_stream_to_vector_0_3_0, '0', blocks_null_sink_2, '14']
- [blocks_stream_to_vector_0_4, '0', blocks_null_sink_2, '8']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_0, '1', blocks_null_sink_1, '0']
- [epy_block_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [epy_block_0_0, '1', blocks_null_sink_1_0, '0']
- [epy_block_0_0_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [epy_block_0_0_0, '1', blocks_null_sink_1_0_0, '0']
- [epy_block_0_0_0_0, '0', qtgui_vector_sink_f_0_0_0_0, '0']
- [epy_block_0_0_0_0, '1', blocks_null_sink_1_0_0_0, '0']
- [epy_block_0_0_1, '0', qtgui_vector_sink_f_0_0_1, '0']
- [epy_block_0_0_1, '1', blocks_null_sink_1_0_1, '0']
- [epy_block_0_1, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_0_1, '1', blocks_null_sink_1_1, '0']
- [epy_block_0_1_0, '0', qtgui_vector_sink_f_0_1_0, '0']
- [epy_block_0_1_0, '1', blocks_null_sink_1_1_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '0', blocks_stream_to_vector_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '1', blocks_stream_to_vector_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '10', blocks_stream_to_vector_0_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '11', blocks_stream_to_vector_0_1_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '12', blocks_stream_to_vector_0_4, '0']
- [gr_digital_rf_digital_rf_source_0_0, '13', blocks_stream_to_vector_0_0_2, '0']
- [gr_digital_rf_digital_rf_source_0_0, '14', blocks_stream_to_vector_0_1_2, '0']
- [gr_digital_rf_digital_rf_source_0_0, '15', blocks_stream_to_vector_0_2_1, '0']
- [gr_digital_rf_digital_rf_source_0_0, '16', blocks_stream_to_vector_0_0_0_1, '0']
- [gr_digital_rf_digital_rf_source_0_0, '17', blocks_stream_to_vector_0_1_0_1, '0']
- [gr_digital_rf_digital_rf_source_0_0, '18', blocks_stream_to_vector_0_3_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '19', blocks_stream_to_vector_0_0_1_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '2', blocks_stream_to_vector_0_1, '0']
- [gr_digital_rf_digital_rf_source_0_0, '20', blocks_stream_to_vector_0_1_1_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '21', blocks_stream_to_vector_0_2_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '22', blocks_stream_to_vector_0_0_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '23', blocks_stream_to_vector_0_1_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '24', blocks_stream_to_vector_0_1_1_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '25', blocks_stream_to_vector_0_2_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '26', blocks_stream_to_vector_0_0_0_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '27', blocks_stream_to_vector_0_1_0_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '28', blocks_stream_to_vector_0_1_0_0_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '3', blocks_stream_to_vector_0_2, '0']
- [gr_digital_rf_digital_rf_source_0_0, '4', blocks_stream_to_vector_0_0_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '5', blocks_stream_to_vector_0_1_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '6', blocks_stream_to_vector_0_3, '0']
- [gr_digital_rf_digital_rf_source_0_0, '7', blocks_stream_to_vector_0_0_1, '0']
- [gr_digital_rf_digital_rf_source_0_0, '8', blocks_stream_to_vector_0_1_1, '0']
- [gr_digital_rf_digital_rf_source_0_0, '9', blocks_stream_to_vector_0_2_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, properties, blocks_msg_meta_to_pair_0, inmeta]

metadata:
  file_format: 1
