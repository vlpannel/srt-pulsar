options:
  parameters:
    author: Viveca Pannell
    generate_options: qt_gui
    id: pulsar_fromraw
    output_language: python
    title: pulsar_fromraw
  states: {}

blocks:
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: multiple_channels
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: '1024'
  states: {}
- name: multiple_channels
  id: parameter
  parameters:
    type: intx
    value: 'True'
  states: {}
- name: pulsar_hier_32channel_0
  id: pulsar_hier_32channel
  parameters:
    bandwidth: '1'
    baseline_time: '30'
    center_freq: '440'
    deviations: '10'
    dm: '56.77118'
    integration_time: '120'
    period: '.03339'
    samp_rate: '1000000'
  states: {}
- name: pulsar_hier_onechannel_0
  id: pulsar_hier_onechannel
  parameters:
    baseline_time: '30'
    channel: '0'
    deviations: '10'
    integration_time: '120'
    num_channels: '32'
    period: '.03339'
    samp_rate: '1000000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '1000000'
  states: {}
- name: sink_address
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: source_address
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    timeout: '100'
    type: float
    vlen: '1024'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_selector_0, '0', pulsar_hier_onechannel_0, '0']
- [blocks_selector_0, '1', pulsar_hier_32channel_0, '0']
- [blocks_selector_1, '0', zeromq_pub_sink_0, '0']
- [pulsar_hier_32channel_0, '0', blocks_selector_1, '1']
- [pulsar_hier_onechannel_0, '0', blocks_selector_1, '0']
- [zeromq_sub_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
