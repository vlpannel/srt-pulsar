options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: drf_stream
    output_language: python
    title: Testing/Debugging DRF Streams
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: sc16
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: /Users/vivelpanel/Desktop/SRT UROP 2022/SRT Flowgraphs/Testing Output Files/drf_sink_out
    uuid: ''
    vlen: '1'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: misa-l2
    end0: '1653595200033671'
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'True'
    start0: '1653595200000000'
    throttle: 'True'
    top_level_dir: '"/Volumes/NO Name/pulsar/2022-05-26/rf_data"'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: New DRF file is empty (only has metadata)!
    note: New DRF file is empty (only has metadata)!
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', gr_digital_rf_digital_rf_sink_0, '0']

metadata:
  file_format: 1
