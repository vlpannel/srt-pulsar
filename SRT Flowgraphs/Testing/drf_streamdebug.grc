options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: drf_stream
    output_language: python
    title: Testing/Debugging DRF Streams
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 90.9e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: samp_rate_rtl
  id: variable
  parameters:
    value: 2.56e6
  states: {state: disabled}
- name: analog_fm_demod_cf_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate_rtl/10
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: short
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    comment: New DRF file is empty (only has metadata)!
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: sc8
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: '1653595200000000'
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: /Users/vivelpanel/Desktop/SRT UROP 2022/SRT Flowgraphs/Testing Output Files/drf_sink_out
    uuid: lkjhlkjh
    vlen: '2'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: misa-l2
    end0: '1653595299999999'
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'True'
    start0: '1653595200000000'
    throttle: 'False'
    top_level_dir: '"/Volumes/NO Name/pulsar/2022-05-26/rf_data"'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This version works with the RTL-SDR to listen
      to FM radio at freq frequency. Made to test 
      effectiveness of GUI elements. They work alright.
    note: works
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_rtl
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccc
  states: {state: disabled}

connections:
- [analog_fm_demod_cf_0_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_real_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_1, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_vector_to_streams_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [osmosdr_source_0_0, '0', blocks_complex_to_real_0_0, '0']
- [osmosdr_source_0_0, '0', qtgui_sink_x_0_0, '0']
- [osmosdr_source_0_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_fm_demod_cf_0_0, '0']

metadata:
  file_format: 1
