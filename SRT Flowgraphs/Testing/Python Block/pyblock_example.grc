options:
  parameters:
    author: Barry Duggan
    generate_options: qt_gui
    id: embed_py_ex
    output_language: python
    title: Embedded Python Block Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /dev/stdout
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block demo
      """

      #  epy_block_0.py
      #  created 10/17/2019

      import numpy as np
      from gnuradio import gr

      import pmt

      textboxValue = ""

      class my_sync_block(gr.sync_block):
          """
          reads input from a message port
          outputs text
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Embedded Python demo",
                  in_sig = None,
                  out_sig = [np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              global textboxValue

              textboxValue = pmt.symbol_to_string (msg)
              # print (textboxValue)
          
          def work(self, input_items, output_items):
              global textboxValue

              # get length of string
              _len = len(textboxValue)
              if (_len > 0):
                  # terminate with LF
                  textboxValue += "\n"
                  _len += 1
                  # store elements in output array
                  for x in range(_len):
                      output_items[0][x] = ord(textboxValue[x])
                  textboxValue = ""
                  self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
                  return (_len)
              else:
                  return (0)
  states: {}
- name: note_0
  id: note
  parameters: {}
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: input
    type: string
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_0, clear_input, qtgui_edit_box_msg_0, val]
- [qtgui_edit_box_msg_0, msg, epy_block_0, msg_in]

metadata:
  file_format: 1
