options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: metafile
    output_language: python
    title: Make File Meta Source
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: 500e6
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: 128e3
    value: 32e3
  states: {state: disabled}
- name: strobe_value
  id: variable_qtgui_chooser
  parameters:
    label: Tags strobe value
    label0: Strobe = 0
    label1: Strobe = 1
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: string
    value: '0'
  states: {state: disabled}
- name: strobe_value
  id: variable_qtgui_chooser
  parameters:
    label: Tags strobe value
    label0: Strobe = 0
    label1: Strobe = 1
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: string
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      This flow is literally a copy from GNU Radio
      Wiki (https://wiki.gnuradio.org/index.php/File
      _Meta_Sink#Example_Flowgraph)

      ... it works!
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: blocks_file_meta_sink_1
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('Initial'), pmt.from_long(3))
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/testmeta.bin
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_file_meta_sink_1_0
  id: blocks_file_meta_sink
  parameters:
    comment: |-
      Sink storing data and metadata
      in a file. Because "detached"
      parameter is "off", header comes
      embedded in file (not separate
      header file).
    detached: 'False'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('Initial'), pmt.from_long(3))
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/testmeta.bin
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: blocks_tag_share_1
  id: blocks_tag_share
  parameters:
    io_type: float
    share_type: float
  states: {state: disabled}
- name: blocks_tag_share_1_0
  id: blocks_tag_share
  parameters:
    comment: '[Tags + data]'
    io_type: complex
    share_type: complex
  states: {}
- name: blocks_tags_strobe_1
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern('strobe')
    nsamps: '320'
    type: float
    value: pmt.intern(strobe_value)
  states: {state: disabled}
- name: blocks_tags_strobe_1_0
  id: blocks_tags_strobe
  parameters:
    comment: |-
      Adds tags to SDR data to
      create metadata
    key: pmt.intern('strobe')
    nsamps: '320'
    type: complex
    value: pmt.intern(strobe_value)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      Exact copy of the example GNU Radio
      wiki provides for File Meta Sink block.
    note: Exacto
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Example copy but modified (complex
      and taking in RTL-SDR input)

      ... it works (complex)
      ... it works! (recording SDR data)
    note: RTL-SDR --> File w/ Metadata
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: '[For debugging]'
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_1
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    comment: SDR incoming signal
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_tag_share_1, '0']
- [blocks_tag_share_1, '0', blocks_throttle_0, '0']
- [blocks_tag_share_1_0, '0', blocks_file_meta_sink_1_0, '0']
- [blocks_tags_strobe_1, '0', blocks_tag_share_1, '1']
- [blocks_tags_strobe_1_0, '0', blocks_tag_share_1_0, '1']
- [blocks_throttle_0, '0', blocks_file_meta_sink_1, '0']
- [rtlsdr_source_1, '0', blocks_tag_share_1_0, '0']
- [rtlsdr_source_1, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
