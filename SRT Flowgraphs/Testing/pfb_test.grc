options:
  parameters:
    author: vivelpanel
    catch_exceptions: 'True'
    category: '[GRC Hier Blocks]'
    cmake_opt: ''
    comment: ''
    copyright: ''
    description: ''
    gen_cmake: 'On'
    gen_linking: dynamic
    generate_options: qt_gui
    hier_block_src_path: '.:'
    id: pfb_test
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    qt_qss_theme: ''
    realtime_scheduling: ''
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: prompt
    sizing_mode: fixed
    thread_safe_setters: ''
    title: Not titled yet
    window_size: (1000,1000)
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [8, 8]
    rotation: 0
    state: enabled

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: ''
    value: '32000'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [184, 12]
    rotation: 0
    state: enabled
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    affinity: ''
    alias: ''
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    comment: ''
    maxoutbuf: '0'
    minoutbuf: '0'
    nchans: '4'
    osr: '1.0'
    samp_delay: '0'
    taps: ''
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [48, 120.0]
    rotation: 0
    state: true
- name: pfb_channelizer_hier_ccf_0
  id: pfb_channelizer_hier_ccf
  parameters:
    affinity: ''
    alias: ''
    atten: '100'
    bw: '1.0'
    comment: ''
    maxoutbuf: '0'
    minoutbuf: '0'
    n_filterbanks: '4'
    nchans: '3'
    outchans: None
    ripple: '0.1'
    taps: None
    tb: '0.2'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [320, 116.0]
    rotation: 0
    state: true
connections: []

metadata:
  file_format: 1
