options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: test_rf_meta
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: None
    file: /Users/vivelpanel/Desktop/huh
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      # imports from read_data_sample.py
      import digital_rf
      import datetime
      import dateutil.parser
      import calendar


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Embedded Python Block: adaptation of read_data_sample.py that
          reads raw data samples (.h5) with Digital RF and then outputs five
          vectors of data points (complex64).
          """

          def __init__(self, parent_path='/Volumes/NO NAME/pulsar/2022-05-26/rf_data/', channel='misa-l2', target='1971-01-01T00:00:00', veclen=1024):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Digital RF Data Vector Source',   # will show up in GRC
                  in_sig=None,
                  out_sig=[(np.complex64, veclen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.parent_path = parent_path
              self.channel = channel
              self.target = target
              self.veclen = veclen

              # getting channel stuff (reader, bounds, properties, dates)
              self.do = digital_rf.DigitalRFReader(parent_path)
              self.s, self.e = self.do.get_bounds(self.channel)
              self.properties = self.do.get_properties(self.channel)
              self.sr = self.properties['sample_rate_numerator'] / self.properties['sample_rate_denominator']
              self.sd = datetime.datetime.utcfromtimestamp(self.s / self.sr)
              self.ed = datetime.datetime.utcfromtimestamp(self.e / self.sr)

              # initialize number of samples, start index, number of vectors
              self.sindex = self.s
              self.timesthru = 0

              #self.dvec = self.do.read_vector_c81d(self.s, self.veclen, self.channel)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              dvec = self.do.read_vector_c81d(self.sindex, self.veclen, self.channel)
              self.timesthru += 1
              self.sindex = (self.timesthru * self.veclen) + self.s
              if len(dvec) < self.veclen:
                  np.append(dvec, np.zeros(self.veclen - len(dvec)))
              output_items[0][:] = dvec
              return len(output_items[0])
    channel: '''misa-l2'''
    parent_path: '"/Volumes/NO NAME/pulsar/2022-05-26/rf_data"'
    target: '''2022-05-26T20:05:00'''
    veclen: '1024'
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: '"/Volumes/NO NAME/pulsar/2022-05-26/rf_data/"'
    end: ''
    gapless: 'True'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'False'
    start: ''
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: misa-l2
    end0: ''
    gapless: 'True'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'False'
    top_level_dir: /Volumes/NO NAME/pulsar/2022-05-26/rf_data/
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_file_meta_sink_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
