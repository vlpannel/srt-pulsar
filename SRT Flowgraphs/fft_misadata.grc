options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: just_fft
    output_language: python
    title: Just FFT (for Pulsar DSP)
  states: {}

blocks:
- name: channel_end
  id: variable
  parameters:
    value: '1653602399999999'
  states: {}
- name: channel_start
  id: variable
  parameters:
    value: '1653595200000000'
  states: {}
- name: integration
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samples
  id: variable
  parameters:
    value: int(tlen*samp_rate)
  states: {}
- name: tlen
  id: variable
  parameters:
    value: 1/29.7
  states: {}
- name: blocks_interleaved_short_to_complex_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: short
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    comment: Both source and sink blocks work.
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: s16
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: /Users/vivelpanel/Destkop/Downloads/testdrf
    uuid: ''
    vlen: '1'
  states: {}
- name: gr_digital_rf_digital_rf_source_0_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: '''misa-l2'''
    end0: channel_end
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'True'
    start0: channel_start
    throttle: 'False'
    top_level_dir: '''/Volumes/NO NAME/pulsar/2022-05-26/rf_data'''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10000'
    interp: '1'
    type: ccc
  states: {state: disabled}

connections:
- [blocks_interleaved_short_to_complex_2, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_2, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_1, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_interleaved_short_to_complex_2, '0']
- [blocks_vector_to_streams_0, '0', blocks_throttle_1, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0, '0']
- [gr_digital_rf_digital_rf_source_0_0, '0', blocks_vector_to_streams_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
