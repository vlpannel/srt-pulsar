options:
  parameters:
    generate_options: qt_gui
    id: rtlsdr_pulsar_flow_graph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: freq*5
    value: freq
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '49'
  states: {}
- name: gain_range
  id: variable_qtgui_range
  parameters:
    comment: GUI sliders if needed to change variables.
    start: '0'
    step: '1'
    stop: '100'
    value: gain
  states: {state: disabled}
- name: integration
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: samp_rate_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: samp_rate*10
    value: samp_rate
  states: {state: disabled}
- name: samples
  id: variable
  parameters:
    value: 600e6
  states: {}
- name: samples_range
  id: variable_qtgui_range
  parameters:
    comment: QT GUI Ranges to adjust variables via GUI if necessary/desired.
    start: '0'
    step: '1'
    stop: samples*5
    value: samples
  states: {state: disabled}
- name: vec_length
  id: variable
  parameters:
    value: '714520'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/pulsar_rtlsdr_outputfile
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: float
  states: {}
- name: blocks_file_meta_sink_1
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: /Users/vivelpanel/Downloads/testing_meta2
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: /Users/vivelpanel/Desktop/SRT Flowgraphs/pulsar_rtlsdr_outputfile
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/pulsar_rtlsdr_outputfile.bin
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '10'
    type: float
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '83'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_2
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: float
  states: {}
- name: blocks_tag_share_0
  id: blocks_tag_share
  parameters:
    io_type: complex
    share_type: complex
  states: {state: disabled}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    comment: |-
      Needs to be modified
      depending on how we
      want the tagging scheme
      to be
    key: pmt.intern("strobe")
    nsamps: '1000'
    type: complex
    value: pmt.intern("TEST")
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '714520'
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: '[For debugging]'
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_1, '0', blocks_vector_to_stream_1, '0']
- [blocks_integrate_xx_2, '0', blocks_file_meta_sink_0, '0']
- [blocks_integrate_xx_2, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_2, '0', qtgui_number_sink_0, '0']
- [blocks_integrate_xx_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_integrate_xx_1, '0']
- [blocks_tag_share_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_tags_strobe_0, '0', blocks_tag_share_0, '1']
- [blocks_vector_to_stream_1, '0', blocks_integrate_xx_2, '0']
- [rtlsdr_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0_0, '0', blocks_file_meta_sink_1, '0']
- [rtlsdr_source_0_0, '0', blocks_tag_share_0, '0']
- [rtlsdr_source_0_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
