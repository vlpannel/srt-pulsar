options:
  parameters:
    generate_options: qt_gui
    id: pulsar_flow_graph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: integration
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samples
  id: variable
  parameters:
    value: 600e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    comment: |-
      Works, creating .bin file
      ... or any kind of file (text file)
    detached: 'False'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('Initial'), pmt.from_long(3))
    file: /Users/vivelpanel/Desktop/SRT Flowgraphs/pulsar_rtlsdr_outputfile_meta
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: float
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    comment: Cannot read .h5 files
    detached: 'False'
    file: /Volumes/NO NAME/pulsar/2022-05-26/rf_data/misa-l2/drf_properties.h5
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Doesn't work; creates empty files
    file: /Users/vivelpanel/Desktop/pulsar_file_draft.wav
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '10'
    type: float
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '83'
    type: float
    vlen: '714520'
  states: {}
- name: blocks_integrate_xx_2
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '714520'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: |-
      This lower section is just
      to generate something that
      can be stored in a file after
      pulsar processing. (Replaces
      File Meta Source.)
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '714520'
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This is mostly copied from the slideshow.
      Not copied are specific filenames (in File
      Meta Source and File Sink) as well as
      Title/ID of flowchart.
    note: Inexact Copying
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_file_meta_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_integrate_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_1, '0', blocks_vector_to_stream_1, '0']
- [blocks_integrate_xx_2, '0', blocks_file_meta_sink_0, '0']
- [blocks_integrate_xx_2, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_integrate_xx_1, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_integrate_xx_2, '0']

metadata:
  file_format: 1
