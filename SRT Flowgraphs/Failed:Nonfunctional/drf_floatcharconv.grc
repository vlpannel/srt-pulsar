options:
  parameters:
    author: vivelpanel
    generate_options: qt_gui
    id: drf_intfloat
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Converts complex int (complex32) to complex float (complex64)"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Complex Int to Complex Float',   # will show up in GRC
                  in_sig=[np.int32],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              print('init is done!')

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              print('starting work function')
              output_items[0][:] = input_items[0][:].astype(complex64)
              print('items casted')
              return len(output_items[0])
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: '"/Volumes/NO NAME/pulsar/2022-05-26/rf_data/misa-l2"'
    end: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'False'
    start: ''
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: misa-l2
    end0: ''
    gapless: 'True'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'False'
    top_level_dir: '"/Volumes/NO NAME/pulsar/2022-05-26/rf_data"'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_null_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', epy_block_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
