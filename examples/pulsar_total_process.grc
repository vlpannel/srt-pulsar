options:
  parameters:
    author: Viveca Pannell
    generate_options: qt_gui
    id: pulsar_total_process
    output_language: python
    title: Pulsar Processing
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '32'
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(integration_time/period)
    type: float
    vlen: int(samp_rate * period)
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: period/integration_time
    type: float
    vlen: int(samp_rate * period)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(samp_rate * period)
    type: float
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: channels
    type: complex
  states: {bus_sink: true}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(samp_rate * period)
    type: float
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '32'
    type: float
  states: {}
- name: center_freq
  id: parameter
  parameters:
    comment: |-
      Center frequency
      in MHz
    type: eng_float
    value: '440'
  states: {}
- name: channels
  id: parameter
  parameters:
    comment: |-
      Number of
      channels
    type: intx
    value: '32'
  states: {}
- name: dedispersion_incoherent_0
  id: dedispersion_incoherent
  parameters:
    bandwidth: '1'
    center_freq: '440'
    channels: '[]'
    dm: '56.77118'
    num_channels: '32'
    samp_rate: '1000000'
  states: {}
- name: deviations
  id: parameter
  parameters:
    comment: |-
      For median filter:
      Number of 
      deviations until
      point is
      considered
      outlier and thrown
      away
    type: eng_float
    value: '10'
  states: {}
- name: filter_baseline_time
  id: parameter
  parameters:
    comment: |-
      For median filter:
      amount of  time of
      samples to
      consider when
      finding median in
      seconds
    type: eng_float
    value: '10'
  states: {}
- name: fold_block_1_0
  id: fold_block_1
  parameters:
    integration_time: integration_time
    period: period
    samp_rate: samp_rate/channels
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: f32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: sink
    uuid: ''
    vlen: int(samp_rate * period)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import mitarspysigproc.filtertools as filtertools
  states: {}
- name: integration_time
  id: parameter
  parameters:
    comment: |-
      Amount of time to 
      consider samples
      before folding in
      seconds
    type: eng_float
    value: '10'
  states: {}
- name: median_filter_0_16
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_0
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_1
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_10
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_11
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_12
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_13
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_14
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_15
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_16
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_17
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_18
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_19
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_2
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_20
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_21
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_22
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_23
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_24
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_25
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_26
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_27
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_28
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_29
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_3
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_30
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_31
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_4
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_5
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_6
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_7
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_8
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: median_filter_0_16_9
  id: median_filter
  parameters:
    baseline_time: filter_baseline_time
    deviations: deviations
    samp_rate: samp_rate/channels
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Can disable if not in use
    note: one channel
  states: {}
- name: note_1
  id: note
  parameters:
    comment: Disable if not in use
    note: 32 channels using hier
  states: {}
- name: period
  id: parameter
  parameters:
    comment: |-
      Period of pulsar
      in seconds
    type: eng_float
    value: '.335'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: channels
    osr: '1.0'
    taps: taps
  states: {bus_source: true}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: channels
    taps: taps
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: int(samp_rate * period)
    srate: samp_rate
    type: float
    ylabel: Power
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: int(samp_rate * period)
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    comment: |-
      Sample rate
      of incoming
      samples in
      samples per
      second
    type: eng_float
    value: '1000000'
  states: {}
- name: sink
  id: parameter
  parameters:
    comment: |-
      If storing data,
      filepath to data
      file
    type: str
    value: ''
  states: {}
- name: source
  id: parameter
  parameters:
    comment: |-
      Complex data
      source filepath
    type: str
    value: ''
  states: {}
- name: taps
  id: parameter
  parameters:
    comment: Filter taps for PFB
    value: filtertools.kaiser_coeffs(channels)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: 32chan
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: 32chan
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: sink
    timeout: '100'
    type: float
    vlen: int(samp_rate * period)
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: sink
    timeout: '100'
    type: float
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: source
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_complex_to_mag_squared_1, '0', median_filter_0_16_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_const_xx_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_integrate_xx_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_vector_to_streams_0, '0', median_filter_0_16, '0']
- [blocks_vector_to_streams_0, '1', median_filter_0_16_1, '0']
- [blocks_vector_to_streams_0, '10', median_filter_0_16_10, '0']
- [blocks_vector_to_streams_0, '11', median_filter_0_16_11, '0']
- [blocks_vector_to_streams_0, '12', median_filter_0_16_12, '0']
- [blocks_vector_to_streams_0, '13', median_filter_0_16_13, '0']
- [blocks_vector_to_streams_0, '14', median_filter_0_16_14, '0']
- [blocks_vector_to_streams_0, '15', median_filter_0_16_15, '0']
- [blocks_vector_to_streams_0, '16', median_filter_0_16_16, '0']
- [blocks_vector_to_streams_0, '17', median_filter_0_16_17, '0']
- [blocks_vector_to_streams_0, '18', median_filter_0_16_18, '0']
- [blocks_vector_to_streams_0, '19', median_filter_0_16_19, '0']
- [blocks_vector_to_streams_0, '2', median_filter_0_16_2, '0']
- [blocks_vector_to_streams_0, '20', median_filter_0_16_20, '0']
- [blocks_vector_to_streams_0, '21', median_filter_0_16_21, '0']
- [blocks_vector_to_streams_0, '22', median_filter_0_16_22, '0']
- [blocks_vector_to_streams_0, '23', median_filter_0_16_23, '0']
- [blocks_vector_to_streams_0, '24', median_filter_0_16_24, '0']
- [blocks_vector_to_streams_0, '25', median_filter_0_16_25, '0']
- [blocks_vector_to_streams_0, '26', median_filter_0_16_26, '0']
- [blocks_vector_to_streams_0, '27', median_filter_0_16_27, '0']
- [blocks_vector_to_streams_0, '28', median_filter_0_16_28, '0']
- [blocks_vector_to_streams_0, '29', median_filter_0_16_29, '0']
- [blocks_vector_to_streams_0, '3', median_filter_0_16_3, '0']
- [blocks_vector_to_streams_0, '30', median_filter_0_16_30, '0']
- [blocks_vector_to_streams_0, '31', median_filter_0_16_31, '0']
- [blocks_vector_to_streams_0, '4', median_filter_0_16_4, '0']
- [blocks_vector_to_streams_0, '5', median_filter_0_16_5, '0']
- [blocks_vector_to_streams_0, '6', median_filter_0_16_6, '0']
- [blocks_vector_to_streams_0, '7', median_filter_0_16_7, '0']
- [blocks_vector_to_streams_0, '8', median_filter_0_16_8, '0']
- [blocks_vector_to_streams_0, '9', median_filter_0_16_9, '0']
- [dedispersion_incoherent_0, '0', fold_block_1_0, '0']
- [fold_block_1_0, '0', virtual_sink_0, '0']
- [median_filter_0_16, '0', dedispersion_incoherent_0, '0']
- [median_filter_0_16_0, '0', blocks_stream_to_vector_0, '0']
- [median_filter_0_16_1, '0', dedispersion_incoherent_0, '1']
- [median_filter_0_16_10, '0', dedispersion_incoherent_0, '10']
- [median_filter_0_16_11, '0', dedispersion_incoherent_0, '11']
- [median_filter_0_16_12, '0', dedispersion_incoherent_0, '12']
- [median_filter_0_16_13, '0', dedispersion_incoherent_0, '13']
- [median_filter_0_16_14, '0', dedispersion_incoherent_0, '14']
- [median_filter_0_16_15, '0', dedispersion_incoherent_0, '15']
- [median_filter_0_16_16, '0', dedispersion_incoherent_0, '16']
- [median_filter_0_16_17, '0', dedispersion_incoherent_0, '17']
- [median_filter_0_16_18, '0', dedispersion_incoherent_0, '18']
- [median_filter_0_16_19, '0', dedispersion_incoherent_0, '19']
- [median_filter_0_16_2, '0', dedispersion_incoherent_0, '2']
- [median_filter_0_16_20, '0', dedispersion_incoherent_0, '20']
- [median_filter_0_16_21, '0', dedispersion_incoherent_0, '21']
- [median_filter_0_16_22, '0', dedispersion_incoherent_0, '22']
- [median_filter_0_16_23, '0', dedispersion_incoherent_0, '23']
- [median_filter_0_16_24, '0', dedispersion_incoherent_0, '24']
- [median_filter_0_16_25, '0', dedispersion_incoherent_0, '25']
- [median_filter_0_16_26, '0', dedispersion_incoherent_0, '26']
- [median_filter_0_16_27, '0', dedispersion_incoherent_0, '27']
- [median_filter_0_16_28, '0', dedispersion_incoherent_0, '28']
- [median_filter_0_16_29, '0', dedispersion_incoherent_0, '29']
- [median_filter_0_16_3, '0', dedispersion_incoherent_0, '3']
- [median_filter_0_16_30, '0', dedispersion_incoherent_0, '30']
- [median_filter_0_16_31, '0', dedispersion_incoherent_0, '31']
- [median_filter_0_16_4, '0', dedispersion_incoherent_0, '4']
- [median_filter_0_16_5, '0', dedispersion_incoherent_0, '5']
- [median_filter_0_16_6, '0', dedispersion_incoherent_0, '6']
- [median_filter_0_16_7, '0', dedispersion_incoherent_0, '7']
- [median_filter_0_16_8, '0', dedispersion_incoherent_0, '8']
- [median_filter_0_16_9, '0', dedispersion_incoherent_0, '9']
- [pfb_channelizer_ccf_0, '32', blocks_streams_to_vector_0, '32']
- [pfb_decimator_ccf_0, '0', blocks_complex_to_mag_squared_1, '0']
- [virtual_source_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [virtual_source_0, '0', qtgui_vector_sink_f_0, '0']
- [virtual_source_0, '0', zeromq_pub_sink_0, '0']
- [zeromq_sub_source_0, '0', pfb_channelizer_ccf_0, '0']
- [zeromq_sub_source_0, '0', pfb_decimator_ccf_0, '0']

metadata:
  file_format: 1
